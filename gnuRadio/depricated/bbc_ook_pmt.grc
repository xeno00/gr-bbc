options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: bbc_ook_pmt
    output_language: python
    run_options: run
  states: {}

blocks:
- name: CODEWORD_LENGTH
  id: variable
  parameters:
    comment: |-
      Must write as int
      Subtract 3 from exponent
      since in Bytes
      131072 = 2**17
      512 = 2**9
    value: '512'
  states: {}
- name: MESSAGE_LENGTH
  id: variable
  parameters:
    comment: |-
      Must write as int
      Subtract 3 from exponent
      since in Bytes
      128 = 2**7
      8 = 2**3
    value: '16'
  states: {}
- name: bits_per_pack
  id: variable
  parameters:
    value: '8'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 433.937e6
  states: {}
- name: message1
  id: variable
  parameters:
    value: '"HELLO WORLD! Welcome to BBC in GNURadio. This is a jam-resistant codec, and we are sending messages, encoding them, and then try"'
  states: {}
- name: packet
  id: variable
  parameters:
    value: '"ZZOMBIES ATTACK!"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 128e3
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: int (500)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 50e3
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\neil.rogers\OneDrive - afacademy.af.edu\ECE 499 - Secure Communications\sturdy-train\GRConn22\GRCon_BBC_2022\bbc_modulated.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\neil.rogers\OneDrive - afacademy.af.edu\ECE 499 - Secure Communications\sturdy-train\GRConn22\GRCon_BBC_2022\bbc_codeword.dat
    type: float
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(len(packet)*1)
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate / symbol_rate)
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: MESSAGE_LENGTH
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '1e-3'
    init: '0'
    low: '1e-3'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: bits_per_pack
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[ ord (x) for x in packet ]'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, sps=768, clen=2 ** 17, dbug=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='OOK Decoder',  # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]#, (np.byte, int(8))] # save bytes output for later
                  #out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sps = sps
              self.dbug = dbug
              self.clen = clen * 8  # to bits from bytes, if using the string method
              self.zcount = 0
              self.ocount = 0
              self.prev_samp = 0
              self.current_byte = ''  # will be  string representing bits received
              self.output_bytes = bytearray()  # will be the output bytes
              self.output_bytes_string = ''
              self.spstol = (np.ceil(0.75 * self.sps))
              self.msgportname = "Message"
              self.message_port_register_out(pmt.intern(self.msgportname))
              self.cwb = 0

          def work(self, input_items, output_items):
              data = input_items[0]
              if self.dbug == 1:
                  print("Received Data of size " + str(len(data)))
              i = 0  # loop counter
              # main loop
              for samp in data:
                  i += 1
                  if samp != self.prev_samp:  # if the sample value has changed
                      if (self.ocount >= self.spstol) or (self.zcount >= self.spstol):
                          self.declarebit(int(self.prev_samp))  # will update self.current_byte
                          self.ocount = 0  # reset the counters
                          self.zcount = 0

                  if samp == 1:
                      self.ocount += 1
                  elif samp == 0:
                      self.zcount += 1
                  else:
                      print("incorrect value for sample on index " + str(i))

                  self.prev_samp = samp  # store the previous sample

                  while len(self.current_byte) >= 8:
                      self.cwb += 1
                      ## for some reason, this one doesn't work...
                      # self.output_bytes = self.output_bytes + bytearray(chr(int(self.current_byte[0:8],2)),'utf-8') # output_bytes are bytes
                      self.output_bytes_string = self.output_bytes_string + self.current_byte[0:8]  # output_bytes is a string
                      self.current_byte = self.current_byte[8:]
                      # self.message_port_pub(pmt.intern(self.msgportname), pmt.intern(self.current_byte[0:8])) # debugging
                      if self.dbug == 1:
                          print("Found " + str(self.cwb) + " bytes so far.")
                          # print(self.current_byte[0:8]) # only get the first 8 bits
                          print("len of output_bytes is " + str(len(self.output_bytes_string)))

              ## if we're at the end and have bits in current_byte, then, add them to output_byte_string
              if (self.ocount >= self.spstol) and (len(self.current_byte) == 7) and (len(self.output_bytes_string) <= self.clen):
                  # this might just be a dirty hack for now, need to figure out a better way to check if there's a partial
                  ## byte and ocount is high enough
                  self.declarebit(int(1)) # will update self.current_byte
                  self.output_bytes_string = self.output_bytes_string + self.current_byte[0:8]  # output_bytes is a string
                  self.current_byte = ''
                  self.ocount = 0

              # now we can see if we have a codeword to output
              if len(self.output_bytes_string) >= self.clen:
                  if self.dbug == 1:
                      print("Found a codeword")
                      print("current_byte is " + str(self.current_byte))
                      print("Bytes found are: " + str(self.output_bytes_string))
                  # import pdb
                  # pdb.set_trace()
                  # output the codeword
                  # need to break up the codeword into byte-sized chunks and transmit them
                  #for k in range(1,int((self.clen/8) + 1)):
                  for k in range(0, int((self.clen / 8) )):
                      bytes_to_send = self.output_bytes_string[self.clen-(k*8):self.clen-((k-1)*8)]
                      bytes_to_send = self.output_bytes_string[k*8:(k+1)*8]
                      self.message_port_pub(pmt.intern(self.msgportname), pmt.intern(bytes_to_send))

                  ## what a one-liner, converts to bytearray: https://stackoverflow.com/questions/32675679/convert-binary-string-to-bytearray-in-python-3
                  ## save the bytes output for later
                  #self.output_bytes = bytearray(int(self.output_bytes_string[:int(self.clen/8)], 2).to_bytes(int((self.clen/8) + 7) // 8, 'big'))
                  #output_items[1][:] =  bytearray(self.output_bytes[:int(self.clen/8)]) # only output 1 codeword at a time
                  #self.message_port_pub(pmt.intern(self.msgportname), pmt.intern(str(self.output_bytes[:int(self.clen / 8)]))) #send bytearray as pmt
                  #self.message_port_pub(pmt.intern(self.msgportname), pmt.intern(self.output_bytes_string[:int(self.clen)])) # send the bytes as a s
                  self.output_bytes_string = self.output_bytes_string[self.clen:]  # pare the string
              else:
                  if self.dbug == 1:
                      print("No codeword yet")
              if self.dbug == 1:
                  print("Current byte is: " + self.current_byte)
                  print("Leftover Ocount is: " + str(self.ocount))
                  print("Leftover Zcount is: " + str(self.zcount))

              ## just output what we got in
              output_items[0][:] = input_items[0]
              return len(output_items[0])

          def declarebit(self, bitval: int):
              if bitval == 1:
                  cnt = self.ocount
              else:
                  cnt = self.zcount
              [bits, bmod] = np.divmod(cnt, self.sps)  # the floor
              if bmod >= self.spstol:  # if the modulus is more than required for a bit, add another bit
                  bits += 1  # see if we have enough samples left over to declare a bit
              self.current_byte = self.current_byte + (str(bitval) * int(bits))  # JAMES
    clen: CODEWORD_LENGTH
    dbug: '0'
    sps: int(samp_rate / symbol_rate)
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      D E C O D E R
      """
      #import sys    #sys.setrecursionlimit((msg_len+1)*8)    after gr.sync_block.__init__()
      import numpy as np
      from gnuradio import gr
      from gnuradio import grc
      from math import ceil
      import inspect
      import pmt
      #import pytictoc

      DEFAULT_CHECKSUM = 0
      #TODO: REMOVE FIRST HANDLING TO MAKE VERSATILE
      global first
      first = True

      class blk(gr.sync_block):

          def __init__(self, dbug=0, msg_len=2**7,cod_len=2**17): #If there is an error, change default here:
              #msg_len = get_top_variable("MESSAGE_LENGTH", default=2**0)
              #cod_len = get_top_variable("CODEWORD_LENGTH", default=2**3)

              gr.sync_block.__init__(self,
                  name='BBC Decoder',
                  #in_sig=[(np.byte,  cod_len if isinstance(cod_len, int) else int(cod_len))],
                  #out_sig=[(np.byte, msg_len if isinstance(msg_len, int) else int(msg_len))]
                  in_sig=None,
                  out_sig=None
              )
              # Convert from Bytes to bits
              # self.tr = TicToc()
              # self.td = TicToc()
              self.msg_len = msg_len  # bytes
              self.cod_len = cod_len # bytes
              self.dbug = dbug
              self.portNameOut = "msgOutput"
              self.portNameIn = "msgInput"
              self.message_port_register_in(pmt.intern(self.portNameIn))
              self.set_msg_handler(pmt.intern(self.portNameIn),self.handle_msg)
              self.message_port_register_out(pmt.intern(self.portNameOut))
              self.myDecoder = Decoder(msg_len*8, cod_len*8, DEFAULT_CHECKSUM) # Bytes to bits
              self.codeword = b''
              #sys.setrecursionlimit((msg_len+1)*8)

          # Use BBC to decode the incoming codeword vectors
          def work(self, input_items, output_items):
              pass

          def handle_msg(self,msg):

              # len(self.codeword) < self.cod_len:
              msg = pmt.symbol_to_string(msg) # convert to a string
              if self.dbug == 1:
                  print("Received Message: " + msg)
              self.codeword = self.codeword + bytearray(int(msg, 2).to_bytes(1, 'big'))
              if self.dbug == 1:
                  print("Codeword so far is " + str(self.codeword))
              if len(self.codeword) == self.cod_len:
                  #self.td.tic()
                  self.decode_and_output()
                  #self.td.toc("Decode")
              # else:
              #     self.decode_and_output() # don't think we'll ever get here
                  # import pdb
                  # pdb.set_trace()

          def decode_and_output(self):
              #result = self.myDecoder.decode(input_items[0][:][:][0])
              result = self.myDecoder.decode(self.codeword)
              try:
                  xtemp = [b'']
                  #i=0
                  for x in result:
                      #print(x) # works
                      #xtemp[0] = xtemp[0] + b'\n' + bytearray(x) # works
                      PMT_msg = pmt.intern(x.decode('utf-8' + "\n")) # works
                      self.message_port_pub(pmt.intern(self.portNameOut),PMT_msg) # works
                  #output_items[0][:] = xtemp[0]  # works
                  if self.dbug == 1:
                      print("Messages found")
                      #print(output_items[0][:].decode())
                  #output_items[0] = input_items[0] # for pass through
                  #return len(output_items[0]) # GR probably needs this
              except:
                  print("Error in parsing output message, probably a hallucination.")
                  #print("DEBUG decoder line 33: output typing failed.\n")
                  #print("Type of decoder result: ", type(bytearray(result)))
                  #print("Type of stream: ", type(self.out_sig))

      ###############################################################################
      class Decoder:
          def __init__(self, MSG_LEN, COD_LEN, CHK_LEN = 0):
              self.message_list = []
              self.num_checksum = DEFAULT_CHECKSUM
              self.shift_register = self.init_shift_register()
              self.MSG_LEN = MSG_LEN
              self.COD_LEN = COD_LEN
              self.CHK_LEN = CHK_LEN #Is added to MSG_LEN, not subtracted from
              self.n = 0

          def init_shift_register(self):
              shift_register = [0 for i in range(32)]
              init(shift_register)
              return (shift_register)

          #DECODE ITERATIVELY
          #Note that   D[n]   is the same as    memoryview(message)[int((self.n - self.n%8)/8)]
          def decode(self, packet):
              # Initialize variables
              self.message_list = []
              message = bytearray(ceil((self.MSG_LEN + self.CHK_LEN)/8))      #Bits to Bytes
              #memoryview(message)[int((self.n - self.n%8)/8)] = 1         # TODO: debug initialization for D[n]
              
              global first
              while first and True:
                  # Check for mark corresponding to encoding D[n], beginning with a 0
                  prop_bit = (memoryview(message)[int((self.n - self.n%8)/8)]>>(self.n%8)) & 0b1      # Find the proposed bit from previous execution, aka D[n]
                  val = (add_bit(prop_bit, self.shift_register) % (self.COD_LEN))                  # Mark location from glowworm
                  bit = (memoryview(packet)[int((val-val%8)/8)]>>(val%8)) & 0b1                       # Logical AND to determine if present in packet/codeword

                  # If the mark is present... explore
                  if bit==1:
                      # message is complete, write to buffer
                      if self.n == (self.MSG_LEN + self.CHK_LEN - 1):
                          #print(message)
                          self.message_list.append(bytes(memoryview(message)[0:self.MSG_LEN - 1 - self.num_checksum]))
                          bit = 0
                          #TODO: Flow control statement?
                          
                      # message is incomplete, continue assuming next bit is 0
                      elif self.n < (self.MSG_LEN + self.CHK_LEN - 1):
                          self.n += 1
                          memoryview(message)[int((self.n - self.n%8)/8)] &= (0xff ^ (1<<self.n%8))
                          continue
                      # In case something bad happens
                      else:
                          raise Exception("107: Message completion led to over-indexing")


                  # If the mark is not present... backtrace
                  # Settle on an earlier 0 to change it to a 1 and pursue that tree
                  if bit!=1:
                      # delete checksum bits
                      while self.n >= self.MSG_LEN: 
                          del_bit(0, self.shift_register)
                          self.n -= 1
                          
                      # delete 1's until a 0 is encountered
                      while self.n >=0 and (((memoryview(message)[int((self.n - self.n%8)/8)]>>(self.n%8)) & 0b1 )==1):
                          del_bit(1, self.shift_register)
                          memoryview(message)[int((self.n - self.n%8)/8)] &= (0xff ^ (1<<self.n%8))
                          self.n -= 1
                              
                      if self.n < 0: #Packet is fully decoded
                          print("Packet is fully decoded. Still need to mplement multiple messages in GRC (decoder)")
                          break #proceed with next packet

                      else: # Move over to the 1 branch of current search
                          del_bit(0, self.shift_register)
                          memoryview(message)[int((self.n - self.n%8)/8)] |= (1<<self.n%8)
              first = False
              #for x in self.message_list:
                  #print(x)
              #print(self.message_list)
              return self.message_list

      ###############################################################################
      MAX_VAL = 0xffffffffffffffff
      global n
      n = 0       
      def add_bit(b, s):
          global n
          t = (s[n % 32]^(0xffffffff if b else 0)) &MAX_VAL
          t = ((t|(t>>1)) ^ ((t<<1)&MAX_VAL))&MAX_VAL     # Have to enforce 64 bit condition on left shift     
          t = (t ^ (t>>4) ^ (t>>8) ^ (t>>16) ^ (t>>32)) & MAX_VAL
          n += 1                           
          s[n % 32] ^= (t&MAX_VAL)  #s[(n) % 32] ^= t, modified to reflect n change
          return s[n % 32]    #return s[(n) % 32], modified to reflect n change                      

      def del_bit(b, s):
          global n
          n -= 1
          add_bit(b,s), 
          n -= 1
          return s[n % 32]
          
      def init(s):
          global n
          n = 0
          h = 1
          for i in range(32):
              s[i]=0
          for i in range(4096):
              h=add_bit(h&1, s)
          n = 0    

      ##############################################################################

      def get_top_variable(variable_name="", default=None):
          '''
          Returns the value of a variable from the flow graph.
          '''
          ## Run Condition: GNURadio is starting the flowgraph, resulting output comes from here when working
          top = inspect.currentframe().f_back.f_back.f_locals
          try:
              # Check if top has the variable name we're looking for
              if top.__contains__(variable_name):
                  #print(f"[Block Debug 1] While starting, I found top variable \'{variable_name}\': type={type(top[variable_name])}, value={top[variable_name]}")
                  return top[variable_name]
          finally:
              del top

          ## Run Condition: Saving the flowgraph, necessary when default case isnt correct. Removed return to fix error
          top = inspect.currentframe().f_back.f_back.f_back.f_back.f_back.f_locals
          try:
              # Make sure top has 'self'
              if top.__contains__("self") and \
                      (isinstance(top['self'], grc.gui.canvas.flowgraph.FlowGraph)) and \
                      (hasattr(top['self'], 'blocks')):

                  # Get a list of all blocks
                  block_names = [block.name for block in top['self'].blocks]

                  # Find the index to the variable we need
                  block_index = block_names.index(variable_name)

                  # Return result
                  result = top["self"].blocks[block_index].params['value'].value
                  print(result)
                  #print(f"[Block Debug 2] While modifying the flowgraph, I found top variable \'{variable_name}\': type={type(result)}, value={result}")
                  #return result

          finally:
              del top

          print("returining default vaule")
          return default
    cod_len: CODEWORD_LENGTH
    dbug: '0'
    msg_len: MESSAGE_LENGTH
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      E N C O D E R
      """
      #import sys
      import numpy as np
      from gnuradio import gr
      from gnuradio import grc
      import inspect
      DEFAULT_CHECKSUM = 0




      class blk(gr.sync_block):
          
          def __init__(self, dbug=0):
              msg_len = get_top_variable("MESSAGE_LENGTH", default=2**7)
              cod_len = get_top_variable("CODEWORD_LENGTH", default=2**17)
              
              gr.sync_block.__init__(self,
                  name='BBC Encoder',
                  in_sig=[(np.byte,  msg_len if isinstance(msg_len, int) else int(msg_len))],    
                  out_sig=[(np.byte, cod_len if isinstance(cod_len, int) else int(cod_len))]
              )
              # Convert from Bytes to bits
              self.myEncoder = Encoder(msg_len*8, cod_len*8)
              self.dbug = dbug
          
          # Use BBC to encode the incoming message vectors
          def work(self, input_items, output_items):
              result = self.myEncoder.encode(input_items[0][:][:])
              result[-1] = result[-1] | 1 # make the last bit 1, for the ook decoder...
              try:
                  if self.dbug == 1:
                      cw = format(int.from_bytes(result,byteorder="little"),'08b')
                      zpad = '0'*(8-(len(cw)%8))
                      cw = zpad + cw
                      print("Codeword is: " + str(result))
                      print("Codeword in binary is: ")
                      while len(cw) >=8:
                          print(cw[len(cw)-8:len(cw)])
                          cw = cw[0:len(cw)-8]
                  output_items[0][:][:] = result
                  return len(output_items[0])
              except:
                  #print("DEBUG encoder line 31: output typing failed.\n")
                  #print("Type of encoder result: ", type(result))
                  #print("Type of stream: ", type(self.out_sig))
                  print("Error while encoding")
      ###############################################################################
      class Encoder:
          def __init__(self, msg_len, cod_len):
              self.shift_register = self.init_shift_register()
              self.msg_len = msg_len
              self.cod_len = cod_len

          def init_shift_register(self):
              shift_register = [0 for i in range(32)]
              init(shift_register)
              return (shift_register)

          def parse_input(self, my_input):
              message = bytearray(my_input.tobytes())
              #TODO: add error exception for wrong sized input vector
              return message

          def encode(self, input):
              message = self.parse_input(input)
              codeword = bytearray(int(self.cod_len/8))
              
              for i in range(self.msg_len):
                  element = memoryview(message)[int((i-i%8)/8)]
                  bit = ((element) >> (i%8)) & 0b1
                  mark_loc = add_bit(bit, self.shift_register) % self.cod_len
                  memoryview(codeword)[int((mark_loc-mark_loc%8)/8)] |= (1<<(mark_loc%8))
                  # TODO: add + vs | change to python library
              return(codeword)
              
       ##############################################################################
      MAX_VAL = 0xffffffffffffffff
      global n
      n = 0       
      def add_bit(b, s):
          global n
          t = (s[n % 32]^(0xffffffff if b else 0)) &MAX_VAL
          t = ((t|(t>>1)) ^ ((t<<1)&MAX_VAL))&MAX_VAL     # Have to enforce 64 bit condition on left shift     
          t = (t ^ (t>>4) ^ (t>>8) ^ (t>>16) ^ (t>>32)) & MAX_VAL
          n += 1                           
          s[n % 32] ^= (t&MAX_VAL)  #s[(n) % 32] ^= t, modified to reflect n change
          return s[n % 32]        #return s[(n) % 32], modified to reflect n change                      

      def del_bit(b, s):
          global n
          n -= 1
          add_bit(b,s), 
          n -= 1
          return s[n % 32]
          
      def init(s):
          global n
          n = 0
          h = 1
          for i in range(32):
              s[i]=0
          for i in range(4096):
              h=add_bit(h&1, s)
          n = 0    
      ###############################################################################

      def get_top_variable(variable_name="", default=None):
          '''
          Returns the value of a variable from the flow graph.
          '''
          ## Run Condition: GNURadio is starting the flowgraph, resulting output comes from here when working
          top = inspect.currentframe().f_back.f_back.f_locals
          try:
              # Check if top has the variable name we're looking for
              if top.__contains__(variable_name):
                  #print(f"[Block Debug 1] While starting, I found top variable \'{variable_name}\': type={type(top[variable_name])}, value={top[variable_name]}")
                  return top[variable_name]
          finally:
              del top

          ## Run Condition: Saving the flowgraph, necessary when default case isnt correct
          top = inspect.currentframe().f_back.f_back.f_back.f_back.f_back.f_locals
          try:
              # Make sure top has 'self'
              if top.__contains__("self") and \
                      (isinstance(top['self'], grc.gui.canvas.flowgraph.FlowGraph)) and \
                      (hasattr(top['self'], 'blocks')):

                  # Get a list of all blocks
                  block_names = [block.name for block in top['self'].blocks]

                  # Find the index to the variable we need
                  block_index = block_names.index(variable_name)
                  
                  # Return result
                  result = top['self'].blocks[block_index].params['value'].value
                  print(f"[Block Debug 2] While modifying the flowgraph, I found top variable \'{variable_name}\': type={type(result)}, value={result}")
                  return result

          finally:
              del top

          print("returining default vaule")
          return default
    comment: |-
      BBC Requires vectors
      for operation
    dbug: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pytictoc
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: carrier_freq
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"OOK TX"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: int(samp_rate *8*16/ symbol_rate)
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 10e3
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ookTx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ookTx
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: '"tcp://127.0.0.1:5557"'
    timeout: '100'
    type: byte
    vlen: CODEWORD_LENGTH
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', osmosdr_sink_0, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_xx_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_repeat_0, '0', blocks_float_to_complex_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_2_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_1, '0']
- [blocks_uchar_to_float_0, '0', blocks_file_sink_1, '0']
- [blocks_uchar_to_float_0, '0', blocks_repeat_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_vector_source_x_0, '0', blocks_head_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [epy_block_0, Message, epy_block_0_0, msgInput]
- [epy_block_0_0, msgOutput, blocks_message_debug_0, print]
- [epy_block_2_0, '0', blocks_vector_to_stream_0, '0']
- [virtual_source_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
