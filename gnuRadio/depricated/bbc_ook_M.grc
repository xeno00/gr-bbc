options:
  parameters:
    author: James Morrison
    generate_options: no_gui
    id: BBCCodecMaster
    output_language: python
    title: BBCCodec
  states: {}

blocks:
- name: CODEWORD_LENGTH
  id: variable
  parameters:
    comment: |-
      Must write as int
      Subtract 3 from exponent
      since in Bytes
      131072 = 2**17
      512 = 2**9
    value: '2'
  states: {}
- name: MESSAGE_LENGTH
  id: variable
  parameters:
    comment: |-
      Must write as int
      Subtract 3 from exponent
      since in Bytes
      128 = 2**7
      8 = 2**3
    value: '1'
  states: {}
- name: bits_per_pack
  id: variable
  parameters:
    value: '8'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 433.937e6
  states: {}
- name: message1
  id: variable
  parameters:
    value: '"HELLO WORLD! Welcome to BBC in GNURadio. This is a jam-resistant codec, and we are sending messages, encoding them, and then try"'
  states: {state: disabled}
- name: message2
  id: variable
  parameters:
    value: '"ZELLO ZORLD! Zelcome zo ZBC zn ZNURadio. Zhis zs z zam-zesistant zodec, znd ze zre zending zessages, zncoding zhem, znd zhen zry"'
  states: {state: disabled}
- name: message3
  id: variable
  parameters:
    value: '"2"'
  states: {}
- name: message4
  id: variable
  parameters:
    value: '"!"'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 128e3
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: int (500)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 50e3
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_or_xx_0
  id: blocks_or_xx
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate / symbol_rate)
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: MESSAGE_LENGTH
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: MESSAGE_LENGTH
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '1e-3'
    init: '0'
    low: '1e-3'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: '32000'
    type: byte
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: bits_per_pack
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[ord(i) for i in message3]'
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: '[ord(i) for i in message4]'
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: MESSAGE_LENGTH
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_1
  id: blocks_vector_to_stream
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      D E C O D E R
      """
      #import sys    #sys.setrecursionlimit((msg_len+1)*8)    after gr.sync_block.__init__()
      import numpy as np
      from gnuradio import gr
      from gnuradio import grc
      from math import ceil
      import inspect
      DEFAULT_CHECKSUM = 0
      #TODO: REMOVE FIRST HANDLING TO MAKE VERSATILE
      global first
      first = True

      class blk(gr.interp_block):

          def __init__(self): #If there is an error, change default here:
              msg_len = get_top_variable("MESSAGE_LENGTH", default=1)#2**7)
              cod_len = get_top_variable("CODEWORD_LENGTH", default=2)#2**17)
              
              gr.sync_block.__init__(self,
                  name='BBC Decoder',
                  in_sig=[(np.byte,  cod_len if isinstance(cod_len, int) else int(cod_len))],
                  out_sig=[(np.byte, msg_len if isinstance(msg_len, int) else int(msg_len))]
              )
              self.set_relative_rate(1)
              # Convert from Bytes to bits
              self.myDecoder = Decoder(msg_len*8, cod_len*8, DEFAULT_CHECKSUM) # Bytes to bits
              #sys.setrecursionlimit((msg_len+1)*8)

          # Use BBC to decode the incoming codeword vectors
          def work(self, input_items, output_items):
              
              # Pull packet from the queue
              packet = input_items[0][:][0]
              
              # Check for a nonzero codeword
              if sum(packet >0):
                  
                  #print("\nDecoder heard codeword ", packet)
                  result = self.myDecoder.decode(packet)
                  interp = len(result)
                  
                  #Check for a decoded message
                  if interp > 0:
                      
                      # Definre the number of outputs
                      self.set_relative_rate(interp)
                      
                      # Assign outputs iteratively
                      for j in range(interp):
                          try:
                              output_items[0][j][:] = result[j]
                              print("BBC decoder found and passed", result[j])
                          except:
                                  # Decrement the expected output size
                                  #interp -= 1
                                  print("BBC decoder found non-ASCII value:", result[j])
                      #return len(output_items) #interp
              return len(output_items)

      ###############################################################################
      class Decoder:
          def __init__(self, MSG_LEN, COD_LEN, CHK_LEN = 0):
              self.message_list = []
              self.num_checksum = DEFAULT_CHECKSUM
              self.shift_register = self.init_shift_register()
              self.MSG_LEN = MSG_LEN
              self.COD_LEN = COD_LEN
              self.CHK_LEN = CHK_LEN #Is added to MSG_LEN, not subtracted from
              self.n = 0

          def init_shift_register(self):
              shift_register = [0 for i in range(32)]
              init(shift_register)
              return (shift_register)

          #DECODE ITERATIVELY
          #Note that   D[n]   is the same as    memoryview(message)[int((self.n - self.n%8)/8)]
          def decode(self, packet):
              # Initialize variables
              self.message_list = []
              message = bytearray(ceil((self.MSG_LEN + self.CHK_LEN)/8))      #Bits to Bytes
              #memoryview(message)[int((self.n - self.n%8)/8)] = 1         # TODO: debug initialization for D[n]
              
              while True:
                  # Check for mark corresponding to encoding D[n], beginning with a 0
                  prop_bit = (memoryview(message)[int((self.n - self.n%8)/8)]>>(self.n%8)) & 0b1      # Find the proposed bit from previous execution, aka D[n]
                  val = (add_bit(prop_bit, self.shift_register) % (self.COD_LEN))                  # Mark location from glowworm
                  bit = (memoryview(packet)[int((val-val%8)/8)]>>(val%8)) & 0b1                       # Logical AND to determine if present in packet/codeword

                  # If the mark is present... explore
                  if bit==1:
                      # message is complete, write to buffer
                      if self.n == (self.MSG_LEN + self.CHK_LEN - 1):
                          #print(message)
                          valid_msg = bytearray(memoryview(message)[0:self.MSG_LEN - 1 - self.num_checksum])
                          self.message_list.append(bytes(message))
                          bit = 0
                          #TODO: Flow control statement?
                          
                      # message is incomplete, continue assuming next bit is 0
                      elif self.n < (self.MSG_LEN + self.CHK_LEN - 1):
                          self.n += 1
                          memoryview(message)[int((self.n - self.n%8)/8)] &= (0xff ^ (1<<self.n%8))
                          continue
                      # In case something bad happens
                      else:
                          raise Exception("107: Message completion led to over-indexing")


                  # If the mark is not present... backtrace
                  # Settle on an earlier 0 to change it to a 1 and pursue that tree
                  if bit!=1:
                      # delete checksum bits
                      while self.n >= self.MSG_LEN: 
                          del_bit(0, self.shift_register)
                          self.n -= 1
                          
                      # delete 1's until a 0 is encountered
                      while self.n >=0 and (((memoryview(message)[int((self.n - self.n%8)/8)]>>(self.n%8)) & 0b1 )==1):
                          del_bit(1, self.shift_register)
                          memoryview(message)[int((self.n - self.n%8)/8)] &= (0xff ^ (1<<self.n%8))
                          self.n -= 1
                              
                      if self.n < 0: #Packet is fully decoded
                          #print("BBC Decoder line 116: Packet is fully decoded. ")
                          break #proceed with next packet

                      else: # Move over to the 1 branch of current search
                          del_bit(0, self.shift_register)
                          memoryview(message)[int((self.n - self.n%8)/8)] |= (1<<self.n%8)
              #for x in self.message_list:
              #    print("Non-iterative output: ",x)
              return self.message_list

      ###############################################################################
      MAX_VAL = 0xffffffffffffffff
      global n
      n = 0       
      def add_bit(b, s):
          global n
          t = (s[n % 32]^(0xffffffff if b else 0)) &MAX_VAL
          t = ((t|(t>>1)) ^ ((t<<1)&MAX_VAL))&MAX_VAL     # Have to enforce 64 bit condition on left shift     
          t = (t ^ (t>>4) ^ (t>>8) ^ (t>>16) ^ (t>>32)) & MAX_VAL
          n += 1                           
          s[n % 32] ^= (t&MAX_VAL)  #s[(n) % 32] ^= t, modified to reflect n change
          return s[n % 32]    #return s[(n) % 32], modified to reflect n change                      

      def del_bit(b, s):
          global n
          n -= 1
          add_bit(b,s), 
          n -= 1
          return s[n % 32]
          
      def init(s):
          global n
          n = 0
          h = 1
          for i in range(32):
              s[i]=0
          for i in range(4096):
              h=add_bit(h&1, s)
          n = 0    

      ###############################################################################
          
      def get_top_variable(variable_name="", default=None):
          '''
          Returns the value of a variable from the flow graph.
          '''
          ## Run Condition: GNURadio is starting the flowgraph, resulting output comes from here when working
          top = inspect.currentframe().f_back.f_back.f_locals
          try:
              # Check if top has the variable name we're looking for
              if top.__contains__(variable_name):
                  #print(f"[Block Debug 1] While starting, I found top variable \'{variable_name}\': type={type(top[variable_name])}, value={top[variable_name]}")
                  return top[variable_name]
          finally:
              del top
              
          ## Run Condition: Saving the flowgraph, necessary when default case isnt correct. Removed return to fix error
          top = inspect.currentframe().f_back.f_back.f_back.f_back.f_back.f_locals
          try:
              # Make sure top has 'self'
              if top.__contains__("self") and \
                      (isinstance(top['self'], grc.gui.canvas.flowgraph.FlowGraph)) and \
                      (hasattr(top['self'], 'blocks')):

                  # Get a list of all blocks
                  block_names = [block.name for block in top['self'].blocks]

                  # Find the index to the variable we need
                  block_index = block_names.index(variable_name)
                  
                  # Return result
                  result = top["self"].blocks[block_index].params['value'].value
                  print(result)
                  #print(f"[Block Debug 2] While modifying the flowgraph, I found top variable \'{variable_name}\': type={type(result)}, value={result}")
                  #return result
              
          finally:
              del top

          print("returining default vaule")
          return default
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      OOK Decoder
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.interp_block):

          def __init__(self, sps=768,clen =2**17, dbug=0): 
              gr.sync_block.__init__(
                  self,
                  name='OOK Decoder',
                  in_sig=[np.float32],
                  out_sig=[np.byte]
              )
              # Set the default Interpolation Rate, i.e. sync case
              self.set_relative_rate(1)
              self.sps = sps
              self.dbug = dbug
              self.clen = clen # to bits from bytes
              self.zcount = 0  # Number of samples of zeros
              self.ocount = 0  # Number of samples of ones
              self.prev_samp =  0
              self.current_byte = '' # will be  string representing bits received
              self.output_bytes = bytearray() # will be the output bytes
              self.spstol = (np.ceil(0.75*self.sps))
              
          def work(self, input_items, output_items):
              
              # Initialize output queue
              output_queue = []
              
              # Use samples to get bitstream
              self.read_samples(input_items[0])
              
              # Peel off bytes from the beginning of the queue
              while len(self.current_byte) >= 8:
                  byte = bytes(chr(int(self.current_byte[0:8],2)),'utf-8')
                  #print("Stripped off ", byte)
                  output_queue.append(byte)
                  self.current_byte = self.current_byte[8:]


              # Use interp block to output the items
              interp = len(output_queue)
              if interp > 0:
                  
                  # Definre the number of outputs
                  self.set_relative_rate(interp)
                  
                  # Assign outputs iteratively
                  for j in range(interp):
                      try:
                          print("Sent ", output_queue[j])
                          output_items[0][j] = output_queue[j]
                      except:
                          print("OOK line 58: Failed to asign output... ", output_queue[j], ". j=", j)
                      
                  # Again, return the number of outputs
                  return len(output_items[0])
              # Otherwise, return nothing
              return 0
                  
          
          
          def read_samples(self, packet):
              i = 0
              for samp in packet:
                  i+=1
                  # Detect a Change
                  if samp != self.prev_samp:
                      if (self.ocount >= self.spstol) or (self.zcount >= self.spstol):
                          if self.prev_samp == 1: # look for ones bits
                              [obits,omod] = np.divmod(self.ocount,self.sps) # the floor
                              if omod >= self.spstol: # if the modulus is more than required for a bit, add another bit
                                  obits +=1
                              otemp = '1'*int(obits) #JAMES
                              self.current_byte = self.current_byte + otemp #JAMES
                          elif self.prev_samp == 0:
                              [zbits,zmod] = np.divmod(self.zcount,self.sps)
                              if zmod >= self.spstol:
                                  zbits +=1
                              ztemp = '0'*int(zbits) #JAMES
                              self.current_byte = self.current_byte + ztemp #JAMES
                          self.ocount = 0 # reset the counters
                          self.zcount = 0
                  
                  # Increment respective sample counter
                  if samp == 1:
                      self.ocount +=1
                  elif samp == 0:
                      self.zcount +=1
                  else:
                      print("incorrect value for sample on index " + str(i))

                  self.prev_samp = samp # store the previous sample
    clen: CODEWORD_LENGTH
    dbug: '0'
    sps: int(samp_rate / symbol_rate)
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      OOK Decoder
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.interp_block):

          def __init__(self, sps=768,clen =2**17, dbug=0): 
              gr.sync_block.__init__(
                  self,
                  name='Work in Progress OOK Decoder',
                  in_sig=[np.float32],
                  out_sig=[np.byte]
              )
              # Set the default Interpolation Rate, i.e. sync case
              self.set_relative_rate(1)
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.bit_counter = 0
              self.sps = sps
              self.dbug = dbug
              self.clen = clen # to bits from bytes
              self.zcount = 0  # Number of samples of zeros
              self.ocount = 0  # Number of samples of ones
              self.prev_samp =  0
              self.current_byte = bytearray('0x00') # will be  string representing bits received
              self.output_bytes = bytearray() # will be the output bytes
              self.spstol = (np.ceil(0.75*self.sps))
              
          def parse_packet(self, packet):
              # Initialize loop counter
              i = 0
              
              # Handle each sample
              for samp in packet:
                  i += 1
                  
                  # Detect a sample change
                  if (samp != self.prev_samp) and (max(self.ocount, self.zcount) >= self.spstol):
                      
                      # If we're detecting ones
                      if self.prev_samp == 1: 
                          [obits,omod] = np.divmod(self.ocount,self.sps) # the floor
                          if omod >= self.spstol: # if the modulus is more than required for a bit, add another bit
                              obits +=1
                          otemp = '1'*int(obits) #JAMES
                          self.bit_counter += obits
                          self.current_byte = self.current_byte + otemp #JAMES
                          
                      # If we're detecing zeros
                      elif self.prev_samp == 0:
                          [zbits,zmod] = np.divmod(self.zcount,self.sps)
                          if zmod >= self.spstol:
                              zbits +=1
                          self.bit_counter += obits
                          
                          self.current_byte = self.current_byte + ztemp #JAMES
                          
                      # Reset the counters
                      self.ocount = 0
                      self.zcount = 0
                      

          def work(self, input_items, output_items):
              data = input_items[0]
              i = 0 # loop counter

               #main loop
              for samp in data:
                  i+=1
                  # Detect a Change
                  if samp != self.prev_samp:
                      if (self.ocount >= self.spstol) or (self.zcount >= self.spstol):
                          if self.prev_samp == 1: # look for ones bits
                              [obits,omod] = np.divmod(self.ocount,self.sps) # the floor
                              if omod >= self.spstol: # if the modulus is more than required for a bit, add another bit
                                  obits +=1
                              otemp = '1'*int(obits) #JAMES
                              self.current_byte = self.current_byte + otemp #JAMES
                          elif self.prev_samp == 0:
                              [zbits,zmod] = np.divmod(self.zcount,self.sps)
                              if zmod >= self.spstol:
                                  zbits +=1
                              ztemp = '0'*int(zbits) #JAMES
                              self.current_byte = self.current_byte + ztemp #JAMES
                          self.ocount = 0 # reset the counters
                          self.zcount = 0
                  
                  # Increment respective sample counter
                  if samp == 1:
                      self.ocount +=1
                  elif samp == 0:
                      self.zcount +=1
                  else:
                      print("incorrect value for sample on index " + str(i))

                  self.prev_samp = samp # store the previous sample

                  while len(self.current_byte) >= 8:
                      # import pdb
                      # pdb.set_trace()
                      if self.dbug == 1:
                          print('got a byte')
                          print(self.current_byte[0:8]) # only get the first 8 bits
                      self.output_bytes = self.output_bytes + bytearray(chr(int(self.current_byte[0:8],2)),'utf-8')
                      #print("len of output_bytes is " + str(len(self.output_bytes)))
                      self.message_port_pub(pmt.intern(self.msgportname), pmt.intern(self.current_byte[0:8]))
                      #self.output_bytes = self.output_bytes + self.current_byte[0:8]
                      self.current_byte = self.current_byte[8:]

              # check to see if the
              #a = self.output_bytes.find(self.sep)
              #if a != -1:
              # import pdb
              # pdb.set_trace()
              if len(self.output_bytes) == self.clen:
                  print("Found a codeword")
                  print("current_byte is " + str(self.current_byte))

              #     #print("Message found is " + self.output_bytes[len(self.sep)-1:a])
                  self.message_port_pub(pmt.intern(self.msgportname), pmt.intern(str(self.output_bytes)))
              #     if a == len(self.output_bytes)-1:
              #         self.output_bytes = ""
              #     else:
              #         self.output_bytes = self.output_bytes[a+len(self.sep):]
                  output_items[1][:] =  self.output_bytes
              else:
                  print("No codeword yet")
                  #output_items[1][:] = bytearray()
              if self.dbug == 1:
                  #print("Bytes found are: " + self.output_bytes)
                  print("Current byte is: " + self.current_byte)
      #           print("Leftover Ocount is: " + str(self.ocount))
      #           print("Leftover Zcount is: " + str(self.zcount))


              # just output what we got in
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    clen: CODEWORD_LENGTH
    dbug: '0'
    sps: int(samp_rate / symbol_rate)
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      '''
      OR CODEWORD BLOCK
      '''
      import numpy as np
      from gnuradio import gr
      from gnuradio import grc
      import inspect


      class blk(gr.sync_block):

          def __init__(self):  # only default arguments here
              cod_len = get_top_variable("CODEWORD_LENGTH", default=2**17)
              
              gr.sync_block.__init__(self,
                  name='OR Codeword',
                  in_sig=[(np.ubyte,  cod_len if isinstance(cod_len, int) else int(cod_len)), 
                          (np.ubyte,  cod_len if isinstance(cod_len, int) else int(cod_len))],    #[np.complex64],
                  out_sig=[(np.ubyte, cod_len if isinstance(cod_len, int) else int(cod_len))]
              )


          def work(self, input_items, output_items):
              #print(input_items[0][0]) gives list without extra binder
              #print(input_items[1])  gives list with extra binder
              result = self.combine_codewords([input_items[1][0], input_items[0][0]]) #output defaults to first argument, here.
              #print(result)
              print("Assigning result")
              print(result[37])
              #output_items[0][:] = input_items[0]    WORKS. Same error if input_items[0][0]
              output_items[0][:] = list(result)
              print("final step")
              #return len(output_items[0])            WORKS
              return len(output_items[0])

          def combine_codewords(self, words):
              result = 0
              #print(type(words[0][0][0]))
              print("decoding 0")
              cw1 = int.from_bytes(words[0],"little")
              print("decoding 1")
              cw2 = int.from_bytes(words[1],"little")
              #for x in words:
              #    result |= int.from_bytes(x,"little")
              print("combining...")
              result = cw1 |cw2
              print("encoding...")
              result = cw1.to_bytes(len(words[0]),"little")#result.to_bytes(len(words[0]),"little")
              print("returning...")
              return result


      ###############################################################################

      def get_top_variable(variable_name="", default=None):
          '''
          Returns the value of a variable from the flow graph.
          '''
          ## Run Condition: GNURadio is starting the flowgraph, resulting output comes from here when working
          top = inspect.currentframe().f_back.f_back.f_locals
          try:
              # Check if top has the variable name we're looking for
              if top.__contains__(variable_name):
                  #print(f"[Block Debug 1] While starting, I found top variable \'{variable_name}\': type={type(top[variable_name])}, value={top[variable_name]}")
                  return top[variable_name]
          finally:
              del top

          ## Run Condition: Saving the flowgraph, necessary when default case isnt correct
          top = inspect.currentframe().f_back.f_back.f_back.f_back.f_back.f_locals
          try:
              # Make sure top has 'self'
              if top.__contains__("self") and \
                      (isinstance(top['self'], grc.gui.canvas.flowgraph.FlowGraph)) and \
                      (hasattr(top['self'], 'blocks')):

                  # Get a list of all blocks
                  block_names = [block.name for block in top['self'].blocks]

                  # Find the index to the variable we need
                  block_index = block_names.index(variable_name)
                  
                  # Return result
                  result = top['self'].blocks[block_index].params['value'].value
                  print(f"[Block Debug 2] While modifying the flowgraph, I found top variable \'{variable_name}\': type={type(result)}, value={result}")
                  return result

          finally:
              del top

          print("returining default vaule")
          return default
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      E N C O D E R
      """
      #import sys
      import numpy as np
      from gnuradio import gr
      from gnuradio import grc
      import inspect
      DEFAULT_CHECKSUM = 0




      class blk(gr.sync_block):
          
          def __init__(self):
              msg_len = get_top_variable("MESSAGE_LENGTH", default=2**7)
              cod_len = get_top_variable("CODEWORD_LENGTH", default=2**17)
              
              gr.sync_block.__init__(self,
                  name='BBC Encoder',
                  in_sig=[(np.byte,  msg_len if isinstance(msg_len, int) else int(msg_len))],    
                  out_sig=[(np.byte, cod_len if isinstance(cod_len, int) else int(cod_len))]
              )
              # Convert from Bytes to bits
              self.myEncoder = Encoder(msg_len*8, cod_len*8)
          
          
          # Use BBC to encode the incoming message vectors
          def work(self, input_items, output_items):
              result = self.myEncoder.encode(input_items[0][:])
              #print("2 encoded: ", result)
              
              try:
                  output_items[0][:] = result
                  return len(output_items[0])
              except:
                  print("DEBUG encoder line 31: output typing failed.\n")
                  print("Type of encoder result: ", type(result))
                  print("Type of stream: ", type(self.out_sig))
          
      ###############################################################################
      class Encoder:
          def __init__(self, msg_len, cod_len):
              self.shift_register = self.init_shift_register()
              self.msg_len = msg_len
              self.cod_len = cod_len

          def init_shift_register(self):
              shift_register = [0 for i in range(32)]
              init(shift_register)
              return (shift_register)

          def parse_input(self, my_input):
              message = bytearray(my_input.tobytes())
              #TODO: add error exception for wrong sized input vector
              return message

          def encode(self, input):
              message = self.parse_input(input)
              codeword = bytearray(int(self.cod_len/8))
              
              for i in range(self.msg_len):
                  element = memoryview(message)[int((i-i%8)/8)]
                  bit = ((element) >> (i%8)) & 0b1
                  mark_loc = add_bit(bit, self.shift_register) % self.cod_len
                  #print(mark_loc)
                  memoryview(codeword)[int((mark_loc-mark_loc%8)/8)] |= (1<<(mark_loc%8))
                  # TODO: add + vs | change to python library
              return(codeword)
              
       ##############################################################################
      MAX_VAL = 0xffffffffffffffff
      global n
      n = 0       
      def add_bit(b, s):
          global n
          t = (s[n % 32]^(0xffffffff if b else 0)) &MAX_VAL
          t = ((t|(t>>1)) ^ ((t<<1)&MAX_VAL))&MAX_VAL     # Have to enforce 64 bit condition on left shift     
          t = (t ^ (t>>4) ^ (t>>8) ^ (t>>16) ^ (t>>32)) & MAX_VAL
          n += 1                           
          s[n % 32] ^= (t&MAX_VAL)  #s[(n) % 32] ^= t, modified to reflect n change
          return s[n % 32]        #return s[(n) % 32], modified to reflect n change                      

      def del_bit(b, s):
          global n
          n -= 1
          add_bit(b,s), 
          n -= 1
          return s[n % 32]
          
      def init(s):
          global n
          n = 0
          h = 1
          for i in range(32):
              s[i]=0
          for i in range(4096):
              h=add_bit(h&1, s)
          n = 0    
      ###############################################################################

      def get_top_variable(variable_name="", default=None):
          '''
          Returns the value of a variable from the flow graph.
          '''
          ## Run Condition: GNURadio is starting the flowgraph, resulting output comes from here when working
          top = inspect.currentframe().f_back.f_back.f_locals
          try:
              # Check if top has the variable name we're looking for
              if top.__contains__(variable_name):
                  #print(f"[Block Debug 1] While starting, I found top variable \'{variable_name}\': type={type(top[variable_name])}, value={top[variable_name]}")
                  return top[variable_name]
          finally:
              del top

          ## Run Condition: Saving the flowgraph, necessary when default case isnt correct
          top = inspect.currentframe().f_back.f_back.f_back.f_back.f_back.f_locals
          try:
              # Make sure top has 'self'
              if top.__contains__("self") and \
                      (isinstance(top['self'], grc.gui.canvas.flowgraph.FlowGraph)) and \
                      (hasattr(top['self'], 'blocks')):

                  # Get a list of all blocks
                  block_names = [block.name for block in top['self'].blocks]

                  # Find the index to the variable we need
                  block_index = block_names.index(variable_name)
                  
                  # Return result
                  result = top['self'].blocks[block_index].params['value'].value
                  print(f"[Block Debug 2] While modifying the flowgraph, I found top variable \'{variable_name}\': type={type(result)}, value={result}")
                  return result

          finally:
              del top

          print("returining default vaule")
          return default
    comment: |-
      BBC Requires vectors
      for operation
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |
      """
      E N C O D E R
      """
      #import sys
      import numpy as np
      from gnuradio import gr
      from gnuradio import grc
      import inspect
      DEFAULT_CHECKSUM = 0




      class blk(gr.sync_block):
          
          def __init__(self):
              msg_len = get_top_variable("MESSAGE_LENGTH", default=2**7)
              cod_len = get_top_variable("CODEWORD_LENGTH", default=2**17)
              
              gr.sync_block.__init__(self,
                  name='BBC Encoder',
                  in_sig=[(np.byte,  msg_len if isinstance(msg_len, int) else int(msg_len))],    
                  out_sig=[(np.byte, cod_len if isinstance(cod_len, int) else int(cod_len))]
              )
              # Convert from Bytes to bits
              self.myEncoder = Encoder(msg_len*8, cod_len*8)
          
          
          # Use BBC to encode the incoming message vectors
          def work(self, input_items, output_items):
              result = self.myEncoder.encode(input_items[0][:][:])
              
              try:
                  output_items[0][:][:] = result
                  return len(output_items[0])
              except:
                  print("DEBUG encoder line 31: output typing failed.\n")
                  print("Type of encoder result: ", type(result))
                  print("Type of stream: ", type(self.out_sig))
          
      ###############################################################################
      class Encoder:
          def __init__(self, msg_len, cod_len):
              self.shift_register = self.init_shift_register()
              self.msg_len = msg_len
              self.cod_len = cod_len

          def init_shift_register(self):
              shift_register = [0 for i in range(32)]
              init(shift_register)
              return (shift_register)

          def parse_input(self, my_input):
              message = bytearray(my_input.tobytes())
              #TODO: add error exception for wrong sized input vector
              return message

          def encode(self, input):
              message = self.parse_input(input)
              codeword = bytearray(int(self.cod_len/8))
              
              for i in range(self.msg_len):
                  element = memoryview(message)[int((i-i%8)/8)]
                  bit = ((element) >> (i%8)) & 0b1
                  mark_loc = add_bit(bit, self.shift_register) % self.cod_len
                  memoryview(codeword)[int((mark_loc-mark_loc%8)/8)] |= (1<<(mark_loc%8))
                  # TODO: add + vs | change to python library
              return(codeword)
              
       ##############################################################################
      MAX_VAL = 0xffffffffffffffff
      global n
      n = 0       
      def add_bit(b, s):
          global n
          t = (s[n % 32]^(0xffffffff if b else 0)) &MAX_VAL
          t = ((t|(t>>1)) ^ ((t<<1)&MAX_VAL))&MAX_VAL     # Have to enforce 64 bit condition on left shift     
          t = (t ^ (t>>4) ^ (t>>8) ^ (t>>16) ^ (t>>32)) & MAX_VAL
          n += 1                           
          s[n % 32] ^= (t&MAX_VAL)  #s[(n) % 32] ^= t, modified to reflect n change
          return s[n % 32]        #return s[(n) % 32], modified to reflect n change                      

      def del_bit(b, s):
          global n
          n -= 1
          add_bit(b,s), 
          n -= 1
          return s[n % 32]
          
      def init(s):
          global n
          n = 0
          h = 1
          for i in range(32):
              s[i]=0
          for i in range(4096):
              h=add_bit(h&1, s)
          n = 0    
      ###############################################################################

      def get_top_variable(variable_name="", default=None):
          '''
          Returns the value of a variable from the flow graph.
          '''
          ## Run Condition: GNURadio is starting the flowgraph, resulting output comes from here when working
          top = inspect.currentframe().f_back.f_back.f_locals
          try:
              # Check if top has the variable name we're looking for
              if top.__contains__(variable_name):
                  #print(f"[Block Debug 1] While starting, I found top variable \'{variable_name}\': type={type(top[variable_name])}, value={top[variable_name]}")
                  return top[variable_name]
          finally:
              del top

          ## Run Condition: Saving the flowgraph, necessary when default case isnt correct
          top = inspect.currentframe().f_back.f_back.f_back.f_back.f_back.f_locals
          try:
              # Make sure top has 'self'
              if top.__contains__("self") and \
                      (isinstance(top['self'], grc.gui.canvas.flowgraph.FlowGraph)) and \
                      (hasattr(top['self'], 'blocks')):

                  # Get a list of all blocks
                  block_names = [block.name for block in top['self'].blocks]

                  # Find the index to the variable we need
                  block_index = block_names.index(variable_name)
                  
                  # Return result
                  result = top['self'].blocks[block_index].params['value'].value
                  print(f"[Block Debug 2] While modifying the flowgraph, I found top variable \'{variable_name}\': type={type(result)}, value={result}")
                  return result

          finally:
              del top

          print("returining default vaule")
          return default
    comment: |-
      BBC Requires vectors
      for operation
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import glowworm.py
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_rx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: bytes
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: demod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: Start BBC Decode
    stream_id: demod
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    comment: Start Modulation
    stream_id: bytes
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    comment: Start Demodulation
    stream_id: tx_rx
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: '"tcp://127.0.0.1:5557"'
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0, '0']
- [blocks_or_xx_0, '0', virtual_sink_1, '0']
- [blocks_repeat_0, '0', blocks_float_to_complex_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_2, '0']
- [blocks_stream_to_vector_0_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0_1, '0', epy_block_2_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_0_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_0, '0', blocks_tag_debug_0, '0']
- [blocks_throttle_0_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_throttle_0_0, '0', blocks_tag_debug_0_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_repeat_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_throttle_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_or_xx_0, '1']
- [blocks_vector_to_stream_1, '0', virtual_sink_1, '0']
- [blocks_vector_to_stream_1_0, '0', zeromq_push_sink_0, '0']
- [blocks_vector_to_stream_1_1, '0', blocks_or_xx_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_1_0, '0']
- [epy_block_0_0, '0', virtual_sink_1_0, '0']
- [epy_block_2, '0', blocks_vector_to_stream_1, '0']
- [epy_block_2_0, '0', blocks_vector_to_stream_1_1, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0_0, '0']
- [virtual_source_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [virtual_source_0_1, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
