options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: ook_transmit
    output_language: python
  states: {}

blocks:
- name: bits_per_pack
  id: variable
  parameters:
    value: '8'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 433.937e6
  states: {}
- name: message1
  id: variable
  parameters:
    value: '"HELLO WORLD! Welcome to BBC in GNURadio. This is a jam-resistant codec, and we are sending messages, encoding them, and...</msg>"'
  states: {}
- name: packet
  id: variable
  parameters:
    value: '"ZZ</msg>"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 128e3
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: int (500)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 50e3
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(len(message1)*5)
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate / symbol_rate)
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '1e-3'
    init: '0'
    low: '1e-3'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: bits_per_pack
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[ ord (x) for x in message1 ]'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, sps=768, dbug=0, sep="</msg>"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='OOK Decoder',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sps = sps
              self.dbug = dbug
              self.zcount = 0
              self.ocount = 0
              self.prev_samp =  0
              self.current_byte = '' # will be  string representing bits received
              self.output_bytes = '' # will be the output string
              self.spstol = (np.ceil(0.75*self.sps))
              self.sep = sep
              self.msgportname = "Message"
              self.message_port_register_out(pmt.intern(self.msgportname))
              
          def work(self, input_items, output_items):
              data = input_items[0]
              i = 0 # loop counter
              
               #main loop
              for samp in data:
                  i+=1
                  if samp != self.prev_samp: # if the sample value has changed
                      if (self.ocount >= self.spstol) or (self.zcount >= self.spstol):
                          ##import pdb
                          #pdb.set_trace()
                          if self.prev_samp == 1: # look for ones bits
                              [obits,omod] = np.divmod(self.ocount,self.sps) # the floor 
                              if omod >= self.spstol: # if the modulus is more than required for a bit, add another bit
                                  obits +=1
                              otemp = '1'*int(obits)
                              self.current_byte = self.current_byte + otemp
                          elif self.prev_samp == 0:
                              [zbits,zmod] = np.divmod(self.zcount,self.sps)
                              if zmod >= self.spstol:
                                  zbits +=1
                              ztemp = '0'*int(zbits)
                              self.current_byte = self.current_byte + ztemp
                          self.ocount = 0 # reset the counters
                          self.zcount = 0
          
                  if samp == 1:
                      self.ocount +=1
                  elif samp == 0:
                      self.zcount +=1
                  else:
                      print("incorrect value for sample on index " + str(i))
          
                  self.prev_samp = samp # store the previous sample
          
                  while len(self.current_byte) >= 8:
                      if self.dbug == 1:
                          print('got a byte')
                          print(self.current_byte[0:8]) # only get the first 8 bits
                      self.output_bytes = self.output_bytes + chr(int(self.current_byte[0:8],2))
                      self.current_byte = self.current_byte[8:]
              
              # check to see if the 
              a = self.output_bytes.find(self.sep)
              if a != -1:
                  #print("Message found is " + self.output_bytes[len(self.sep)-1:a])
                  self.message_port_pub(pmt.intern(self.msgportname),pmt.intern(self.output_bytes[0:a]))
                  if a == len(self.output_bytes)-1:
                      self.output_bytes = ""
                  else:
                      self.output_bytes = self.output_bytes[a+len(self.sep):]
                  
                  
              if self.dbug == 1:
                   print("Bytes found are: " + self.output_bytes)
      #            print("Current byte is: " + self.current_byte)
      #            print("Leftover Ocount is: " + str(self.ocount))
      #            print("Leftover Zcount is: " + str(self.zcount))
          
              
              # just output what we got in
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    dbug: '0'
    sep: '"</msg>"'
    sps: int(samp_rate / symbol_rate)
  states: {}
- name: ook_demod_block
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each this file is saved, GRC will instantiate the first class it finds to get
      ports and parameters of your block. The arguments to __init__  will be the
      parameters. All of them are required to have default values!
      """
      import time
      import numpy as np
      from gnuradio import gr

      class blk (gr.sync_block):
          """
          Block to decode the data on an already squared signal, comprised of 0's and 1's.
          """

          def __init__ (self
                      , symbol_rate = 600
      		, sample_rate = 1e6
      		, manchester_decoding = False
                      , sink_file = None):  # only default arguments here
              """
              Constructor.

              Args:
                  symbol_rate -> Rate of symbols

                  sample_rate -> Number of samples per second

      	    manchester_decoding -> Enable/disable manchester decoding

                  sink_file -> File to dump the packets. If it's 'None', prints them on STDOUT
              """
              gr.sync_block.__init__(
                  self,
                  name = 'OOK demod',
                  in_sig = [np.float32],
                  out_sig = []
              )

      			self.manchester_decoding = manchester_decoding

      	self.sink_file = None
      	if(sink_file != None):
                self.sink_file = open(sink_file, "a")

      	# amount of samples per symbol
      	self.threshold = sample_rate / symbol_rate
      	# amount of samples that can be wrong when counting the 1's and 0's
      	self.error_threshold = self.threshold / 4

      	self.packet = ''
              self.count_1 = 0 # Counts consecutive 1's
      	self.count_0 = 0 # Counts consecutive 0's
      	self.sample_1_complete = False
      	self.sample_0_complete = False


          def packet_found(self):
      	self.packet += '0' # Last 0 of packet is never detected due to the bounded 0 count (in process_sample_0), so add manually

      	if(self.manchester_decoding):
      	  self.packet = self.manchester_decoder(self.packet)

      	self.output_packet(self.packet)
      	self.packet = ''

         
          def output_packet(self, output):
      	if(self.sink_file):
      	  self.sink_file.write(output + '\n')
      	else:
      	  print(output)


          def count_samples(self, sample1, sample2):
      	if(sample1 == 1):
      	  self.count_1 += 1
      	  if(sample2 == 0):
      	    self.sample_1_complete = True 
      	elif(sample1 == 0):
      	  self.count_0 += 1
      	  if(sample2 == 1):
      	    self.sample_0_complete = True 


          def process_sample_0(self):
      	if(self.count_0 > self.threshold - self.error_threshold and self.count_0 < self.threshold + self.error_threshold):
      	  self.packet += '0'
      	elif(self.count_0 > (self.threshold - self.error_threshold) * 2 and self.count_0 < (self.threshold + self.error_threshold) * 2):
      	  self.packet += '00'
      	self.count_0 = 0
      	self.sample_0_complete = False


          def process_sample_1(self):
      	if(self.count_1 > self.threshold - self.error_threshold and self.count_1 < self.threshold + self.error_threshold):
      	  self.packet += '1'
      	elif(self.count_1 > (self.threshold - self.error_threshold) * 2 and self.count_1 < (self.threshold + self.error_threshold) * 2):
      	  self.packet += '11'
      	self.count_1 = 0
      	self.sample_1_complete = False


          def manchester_decoder(self, packet):
      	decode = ''

              for i in range(0, len(packet) - 1, 2):
      	  bits = packet[i] + packet[i + 1]
      	  if(bits == '10'):
      	    decode += '0'
      	  elif(bits == '01'):
      	    decode += '1'
      	  else:
      	    i -= 1

      	return decode



          def work (self, input_items, *args, **kwargs):
              samples = input_items[0]
      	
              signal_detected = np.where(samples == 1)[0]

      	if(len(signal_detected) > 0):
      	  for i in range(0, len(samples) - 1):
      	    self.count_samples(samples[i], samples[i + 1])
      	    if(self.sample_1_complete):
      	      self.process_sample_1()
      	    elif(self.sample_0_complete):
      	      self.process_sample_0()
      	elif(len(samples) > 0 and len(self.packet) > 0):
      	   self.packet_found()

              return len(samples)
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: carrier_freq
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"OOK TX"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"Demod"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ookTx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ookTx
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', osmosdr_sink_0, '0']
- [blocks_head_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_repeat_0, '0', blocks_float_to_complex_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_1_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_1, '0']
- [blocks_uchar_to_float_0, '0', blocks_repeat_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_vector_source_x_0, '0', blocks_head_0, '0']
- [epy_block_1_0, '0', blocks_null_sink_0, '0']
- [epy_block_1_0, Message, blocks_message_debug_0, print]
- [virtual_source_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
