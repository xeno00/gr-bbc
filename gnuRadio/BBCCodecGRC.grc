options:
  parameters:
    author: James Morrison
    generate_options: qt_gui
    id: BBCCodecMaster
    output_language: python
    title: BBCCodec
  states: {}

blocks:
- name: CODEWORD_LENGTH
  id: variable
  parameters:
    comment: |-
      Must write as int
      Subtract 3 from exponent
      since in Bytes
      131072 = 2**17
      512 = 2**9
    value: '131072'
  states: {}
- name: MESSAGE_LENGTH
  id: variable
  parameters:
    comment: |-
      Must write as int
      Subtract 3 from exponent
      since in Bytes
      128 = 2**7
      8 = 2**3
    value: '128'
  states: {}
- name: message1
  id: variable
  parameters:
    value: '"HELLO WORLD! Welcome to BBC in GNURadio. This is a jam-resistant codec, and we are sending messages, encoding them, and then try"'
  states: {}
- name: message2
  id: variable
  parameters:
    value: '"ZELLO ZORLD! Zelcome zo ZBC zn ZNURadio. Zhis zs z zam-zesistant zodec, znd ze zre zending zessages, zncoding zhem, znd zhen zry"'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_or_xx_0
  id: blocks_or_xx
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: MESSAGE_LENGTH
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: MESSAGE_LENGTH
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '32000'
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: '32000'
    type: byte
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: '[ord(i) for i in message1]'
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: '[ord(i) for i in message2]'
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: MESSAGE_LENGTH
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_1
  id: blocks_vector_to_stream
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      D E C O D E R
      """
      #import sys    #sys.setrecursionlimit((msg_len+1)*8)    after gr.sync_block.__init__()
      import numpy as np
      from gnuradio import gr
      from gnuradio import grc
      from math import ceil
      import inspect
      import pmt

      DEFAULT_CHECKSUM = 0
      #TODO: REMOVE FIRST HANDLING TO MAKE VERSATILE
      global first
      first = True

      class blk(gr.sync_block):

          def __init__(self): #If there is an error, change default here:
              msg_len = get_top_variable("MESSAGE_LENGTH", default=2**7)
              cod_len = get_top_variable("CODEWORD_LENGTH", default=2**17)

              gr.sync_block.__init__(self,
                  name='BBC Decoder',
                  in_sig=[(np.byte,  cod_len if isinstance(cod_len, int) else int(cod_len))],
                  out_sig=[(np.byte, msg_len if isinstance(msg_len, int) else int(msg_len))]
                  #out_sig=[np.byte]
              )
              # Convert from Bytes to bits
              self.portName = "msgOutput"
              self.message_port_register_out(pmt.intern(self.portName))
              self.myDecoder = Decoder(msg_len*8, cod_len*8, DEFAULT_CHECKSUM) # Bytes to bits
              #sys.setrecursionlimit((msg_len+1)*8)

          # Use BBC to decode the incoming codeword vectors
          def work(self, input_items, output_items):
              result = self.myDecoder.decode(input_items[0][:][:][0])
              #TODO: add function to iteratively push results out
              try:
                  xtemp = b''
                  for x in result:
                      #print(x) # works
                      xtemp = xtemp + b' ' + bytearray(x)
                      output_items[0][:] = bytearray(x)
                      PMT_msg = pmt.intern(x.decode('utf-8' + "\n")) # works
                      self.message_port_pub(pmt.intern(self.portName),PMT_msg) # works
                  #print(xtemp)
                  #output_items[0][:] = xtemp # doesn't work for some reason, maybe size?
                  #print(len(output_items[0]))
                  #print(output_items[0][:].decode())
                  #output_items[0][:] = input_items[0]
                  return len(output_items[0])
              except:
                  print("DEBUG decoder line 33: output typing failed.\n")
                  #print("Type of decoder result: ", type(bytearray(result)))
                  print("Type of stream: ", type(self.out_sig))

      ###############################################################################
      class Decoder:
          def __init__(self, MSG_LEN, COD_LEN, CHK_LEN = 0):
              self.message_list = []
              self.num_checksum = DEFAULT_CHECKSUM
              self.shift_register = self.init_shift_register()
              self.MSG_LEN = MSG_LEN
              self.COD_LEN = COD_LEN
              self.CHK_LEN = CHK_LEN #Is added to MSG_LEN, not subtracted from
              self.n = 0

          def init_shift_register(self):
              shift_register = [0 for i in range(32)]
              init(shift_register)
              return (shift_register)

          #DECODE ITERATIVELY
          #Note that   D[n]   is the same as    memoryview(message)[int((self.n - self.n%8)/8)]
          def decode(self, packet):
              # Initialize variables
              self.message_list = []
              message = bytearray(ceil((self.MSG_LEN + self.CHK_LEN)/8))      #Bits to Bytes
              #memoryview(message)[int((self.n - self.n%8)/8)] = 1         # TODO: debug initialization for D[n]
              
              global first
              while first and True:
                  # Check for mark corresponding to encoding D[n], beginning with a 0
                  prop_bit = (memoryview(message)[int((self.n - self.n%8)/8)]>>(self.n%8)) & 0b1      # Find the proposed bit from previous execution, aka D[n]
                  val = (add_bit(prop_bit, self.shift_register) % (self.COD_LEN))                  # Mark location from glowworm
                  bit = (memoryview(packet)[int((val-val%8)/8)]>>(val%8)) & 0b1                       # Logical AND to determine if present in packet/codeword

                  # If the mark is present... explore
                  if bit==1:
                      # message is complete, write to buffer
                      if self.n == (self.MSG_LEN + self.CHK_LEN - 1):
                          #print(message)
                          self.message_list.append(bytes(memoryview(message)[0:self.MSG_LEN - 1 - self.num_checksum]))
                          bit = 0
                          #TODO: Flow control statement?
                          
                      # message is incomplete, continue assuming next bit is 0
                      elif self.n < (self.MSG_LEN + self.CHK_LEN - 1):
                          self.n += 1
                          memoryview(message)[int((self.n - self.n%8)/8)] &= (0xff ^ (1<<self.n%8))
                          continue
                      # In case something bad happens
                      else:
                          raise Exception("107: Message completion led to over-indexing")


                  # If the mark is not present... backtrace
                  # Settle on an earlier 0 to change it to a 1 and pursue that tree
                  if bit!=1:
                      # delete checksum bits
                      while self.n >= self.MSG_LEN: 
                          del_bit(0, self.shift_register)
                          self.n -= 1
                          
                      # delete 1's until a 0 is encountered
                      while self.n >=0 and (((memoryview(message)[int((self.n - self.n%8)/8)]>>(self.n%8)) & 0b1 )==1):
                          del_bit(1, self.shift_register)
                          memoryview(message)[int((self.n - self.n%8)/8)] &= (0xff ^ (1<<self.n%8))
                          self.n -= 1
                              
                      if self.n < 0: #Packet is fully decoded
                          print("Packet is fully decoded. Still need to mplement multiple messages in GRC (decoder)")
                          break #proceed with next packet

                      else: # Move over to the 1 branch of current search
                          del_bit(0, self.shift_register)
                          memoryview(message)[int((self.n - self.n%8)/8)] |= (1<<self.n%8)
              first = False
              #for x in self.message_list:
                  #print(x)
              #print(self.message_list)
              return self.message_list

      ###############################################################################
      MAX_VAL = 0xffffffffffffffff
      global n
      n = 0       
      def add_bit(b, s):
          global n
          t = (s[n % 32]^(0xffffffff if b else 0)) &MAX_VAL
          t = ((t|(t>>1)) ^ ((t<<1)&MAX_VAL))&MAX_VAL     # Have to enforce 64 bit condition on left shift     
          t = (t ^ (t>>4) ^ (t>>8) ^ (t>>16) ^ (t>>32)) & MAX_VAL
          n += 1                           
          s[n % 32] ^= (t&MAX_VAL)  #s[(n) % 32] ^= t, modified to reflect n change
          return s[n % 32]    #return s[(n) % 32], modified to reflect n change                      

      def del_bit(b, s):
          global n
          n -= 1
          add_bit(b,s), 
          n -= 1
          return s[n % 32]
          
      def init(s):
          global n
          n = 0
          h = 1
          for i in range(32):
              s[i]=0
          for i in range(4096):
              h=add_bit(h&1, s)
          n = 0    

      ###############################################################################
          
      def get_top_variable(variable_name="", default=None):
          '''
          Returns the value of a variable from the flow graph.
          '''
          ## Run Condition: GNURadio is starting the flowgraph, resulting output comes from here when working
          top = inspect.currentframe().f_back.f_back.f_locals
          try:
              # Check if top has the variable name we're looking for
              if top.__contains__(variable_name):
                  #print(f"[Block Debug 1] While starting, I found top variable \'{variable_name}\': type={type(top[variable_name])}, value={top[variable_name]}")
                  return top[variable_name]
          finally:
              del top
              
          ## Run Condition: Saving the flowgraph, necessary when default case isnt correct. Removed return to fix error
          top = inspect.currentframe().f_back.f_back.f_back.f_back.f_back.f_locals
          try:
              # Make sure top has 'self'
              if top.__contains__("self") and \
                      (isinstance(top['self'], grc.gui.canvas.flowgraph.FlowGraph)) and \
                      (hasattr(top['self'], 'blocks')):

                  # Get a list of all blocks
                  block_names = [block.name for block in top['self'].blocks]

                  # Find the index to the variable we need
                  block_index = block_names.index(variable_name)
                  
                  # Return result
                  result = top["self"].blocks[block_index].params['value'].value
                  print(result)
                  #print(f"[Block Debug 2] While modifying the flowgraph, I found top variable \'{variable_name}\': type={type(result)}, value={result}")
                  #return result
              
          finally:
              del top

          print("returining default vaule")
          return default
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      '''
      OR CODEWORD BLOCK
      '''
      import numpy as np
      from gnuradio import gr
      from gnuradio import grc
      import inspect


      class blk(gr.sync_block):

          def __init__(self):  # only default arguments here
              cod_len = get_top_variable("CODEWORD_LENGTH", default=2**17)
              
              gr.sync_block.__init__(self,
                  name='OR Codeword',
                  in_sig=[(np.ubyte,  cod_len if isinstance(cod_len, int) else int(cod_len)), 
                          (np.ubyte,  cod_len if isinstance(cod_len, int) else int(cod_len))],    #[np.complex64],
                  out_sig=[(np.ubyte, cod_len if isinstance(cod_len, int) else int(cod_len))]
              )


          def work(self, input_items, output_items):
              #print(input_items[0][0]) gives list without extra binder
              #print(input_items[1])  gives list with extra binder
              result = self.combine_codewords([input_items[1][0], input_items[0][0]]) #output defaults to first argument, here.
              #print(result)
              print("Assigning result")
              print(result[37])
              #output_items[0][:] = input_items[0]    WORKS. Same error if input_items[0][0]
              output_items[0][:] = list(result)
              print("final step")
              #return len(output_items[0])            WORKS
              return len(output_items[0])

          def combine_codewords(self, words):
              result = 0
              #print(type(words[0][0][0]))
              print("decoding 0")
              cw1 = int.from_bytes(words[0],"little")
              print("decoding 1")
              cw2 = int.from_bytes(words[1],"little")
              #for x in words:
              #    result |= int.from_bytes(x,"little")
              print("combining...")
              result = cw1 |cw2
              print("encoding...")
              result = cw1.to_bytes(len(words[0]),"little")#result.to_bytes(len(words[0]),"little")
              print("returning...")
              return result


      ###############################################################################

      def get_top_variable(variable_name="", default=None):
          '''
          Returns the value of a variable from the flow graph.
          '''
          ## Run Condition: GNURadio is starting the flowgraph, resulting output comes from here when working
          top = inspect.currentframe().f_back.f_back.f_locals
          try:
              # Check if top has the variable name we're looking for
              if top.__contains__(variable_name):
                  #print(f"[Block Debug 1] While starting, I found top variable \'{variable_name}\': type={type(top[variable_name])}, value={top[variable_name]}")
                  return top[variable_name]
          finally:
              del top

          ## Run Condition: Saving the flowgraph, necessary when default case isnt correct
          top = inspect.currentframe().f_back.f_back.f_back.f_back.f_back.f_locals
          try:
              # Make sure top has 'self'
              if top.__contains__("self") and \
                      (isinstance(top['self'], grc.gui.canvas.flowgraph.FlowGraph)) and \
                      (hasattr(top['self'], 'blocks')):

                  # Get a list of all blocks
                  block_names = [block.name for block in top['self'].blocks]

                  # Find the index to the variable we need
                  block_index = block_names.index(variable_name)
                  
                  # Return result
                  result = top['self'].blocks[block_index].params['value'].value
                  print(f"[Block Debug 2] While modifying the flowgraph, I found top variable \'{variable_name}\': type={type(result)}, value={result}")
                  return result

          finally:
              del top

          print("returining default vaule")
          return default
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      E N C O D E R
      """
      #import sys
      import numpy as np
      from gnuradio import gr
      from gnuradio import grc
      import inspect
      DEFAULT_CHECKSUM = 0




      class blk(gr.sync_block):
          
          def __init__(self):
              msg_len = get_top_variable("MESSAGE_LENGTH", default=2**7)
              cod_len = get_top_variable("CODEWORD_LENGTH", default=2**17)
              
              gr.sync_block.__init__(self,
                  name='BBC Encoder',
                  in_sig=[(np.byte,  msg_len if isinstance(msg_len, int) else int(msg_len))],    
                  out_sig=[(np.byte, cod_len if isinstance(cod_len, int) else int(cod_len))]
              )
              # Convert from Bytes to bits
              self.myEncoder = Encoder(msg_len*8, cod_len*8)
          
          
          # Use BBC to encode the incoming message vectors
          def work(self, input_items, output_items):
              result = self.myEncoder.encode(input_items[0][:][:])
              
              try:
                  output_items[0][:][:] = result
                  return len(output_items[0])
              except:
                  print("DEBUG encoder line 31: output typing failed.\n")
                  print("Type of encoder result: ", type(result))
                  print("Type of stream: ", type(self.out_sig))
          
      ###############################################################################
      class Encoder:
          def __init__(self, msg_len, cod_len):
              self.shift_register = self.init_shift_register()
              self.msg_len = msg_len
              self.cod_len = cod_len

          def init_shift_register(self):
              shift_register = [0 for i in range(32)]
              init(shift_register)
              return (shift_register)

          def parse_input(self, my_input):
              message = bytearray(my_input.tobytes())
              #TODO: add error exception for wrong sized input vector
              return message

          def encode(self, input):
              message = self.parse_input(input)
              codeword = bytearray(int(self.cod_len/8))
              
              for i in range(self.msg_len):
                  element = memoryview(message)[int((i-i%8)/8)]
                  bit = ((element) >> (i%8)) & 0b1
                  mark_loc = add_bit(bit, self.shift_register) % self.cod_len
                  memoryview(codeword)[int((mark_loc-mark_loc%8)/8)] |= (1<<(mark_loc%8))
                  # TODO: add + vs | change to python library
              return(codeword)
              
       ##############################################################################
      MAX_VAL = 0xffffffffffffffff
      global n
      n = 0       
      def add_bit(b, s):
          global n
          t = (s[n % 32]^(0xffffffff if b else 0)) &MAX_VAL
          t = ((t|(t>>1)) ^ ((t<<1)&MAX_VAL))&MAX_VAL     # Have to enforce 64 bit condition on left shift     
          t = (t ^ (t>>4) ^ (t>>8) ^ (t>>16) ^ (t>>32)) & MAX_VAL
          n += 1                           
          s[n % 32] ^= (t&MAX_VAL)  #s[(n) % 32] ^= t, modified to reflect n change
          return s[n % 32]        #return s[(n) % 32], modified to reflect n change                      

      def del_bit(b, s):
          global n
          n -= 1
          add_bit(b,s), 
          n -= 1
          return s[n % 32]
          
      def init(s):
          global n
          n = 0
          h = 1
          for i in range(32):
              s[i]=0
          for i in range(4096):
              h=add_bit(h&1, s)
          n = 0    
      ###############################################################################

      def get_top_variable(variable_name="", default=None):
          '''
          Returns the value of a variable from the flow graph.
          '''
          ## Run Condition: GNURadio is starting the flowgraph, resulting output comes from here when working
          top = inspect.currentframe().f_back.f_back.f_locals
          try:
              # Check if top has the variable name we're looking for
              if top.__contains__(variable_name):
                  #print(f"[Block Debug 1] While starting, I found top variable \'{variable_name}\': type={type(top[variable_name])}, value={top[variable_name]}")
                  return top[variable_name]
          finally:
              del top

          ## Run Condition: Saving the flowgraph, necessary when default case isnt correct
          top = inspect.currentframe().f_back.f_back.f_back.f_back.f_back.f_locals
          try:
              # Make sure top has 'self'
              if top.__contains__("self") and \
                      (isinstance(top['self'], grc.gui.canvas.flowgraph.FlowGraph)) and \
                      (hasattr(top['self'], 'blocks')):

                  # Get a list of all blocks
                  block_names = [block.name for block in top['self'].blocks]

                  # Find the index to the variable we need
                  block_index = block_names.index(variable_name)
                  
                  # Return result
                  result = top['self'].blocks[block_index].params['value'].value
                  print(f"[Block Debug 2] While modifying the flowgraph, I found top variable \'{variable_name}\': type={type(result)}, value={result}")
                  return result

          finally:
              del top

          print("returining default vaule")
          return default
    comment: |-
      BBC Requires vectors
      for operation
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      E N C O D E R
      """
      #import sys
      import numpy as np
      from gnuradio import gr
      from gnuradio import grc
      import inspect
      DEFAULT_CHECKSUM = 0




      class blk(gr.sync_block):
          
          def __init__(self):
              msg_len = get_top_variable("MESSAGE_LENGTH", default=2**7)
              cod_len = get_top_variable("CODEWORD_LENGTH", default=2**17)
              
              gr.sync_block.__init__(self,
                  name='BBC Encoder',
                  in_sig=[(np.byte,  msg_len if isinstance(msg_len, int) else int(msg_len))],    
                  out_sig=[(np.byte, cod_len if isinstance(cod_len, int) else int(cod_len))]
              )
              # Convert from Bytes to bits
              self.myEncoder = Encoder(msg_len*8, cod_len*8)
          
          
          # Use BBC to encode the incoming message vectors
          def work(self, input_items, output_items):
              result = self.myEncoder.encode(input_items[0][:][:])
              
              try:
                  output_items[0][:][:] = result
                  return len(output_items[0])
              except:
                  print("DEBUG encoder line 31: output typing failed.\n")
                  print("Type of encoder result: ", type(result))
                  print("Type of stream: ", type(self.out_sig))
          
      ###############################################################################
      class Encoder:
          def __init__(self, msg_len, cod_len):
              self.shift_register = self.init_shift_register()
              self.msg_len = msg_len
              self.cod_len = cod_len

          def init_shift_register(self):
              shift_register = [0 for i in range(32)]
              init(shift_register)
              return (shift_register)

          def parse_input(self, my_input):
              message = bytearray(my_input.tobytes())
              #TODO: add error exception for wrong sized input vector
              return message

          def encode(self, input):
              message = self.parse_input(input)
              codeword = bytearray(int(self.cod_len/8))
              
              for i in range(self.msg_len):
                  element = memoryview(message)[int((i-i%8)/8)]
                  bit = ((element) >> (i%8)) & 0b1
                  mark_loc = add_bit(bit, self.shift_register) % self.cod_len
                  memoryview(codeword)[int((mark_loc-mark_loc%8)/8)] |= (1<<(mark_loc%8))
                  # TODO: add + vs | change to python library
              return(codeword)
              
       ##############################################################################
      MAX_VAL = 0xffffffffffffffff
      global n
      n = 0       
      def add_bit(b, s):
          global n
          t = (s[n % 32]^(0xffffffff if b else 0)) &MAX_VAL
          t = ((t|(t>>1)) ^ ((t<<1)&MAX_VAL))&MAX_VAL     # Have to enforce 64 bit condition on left shift     
          t = (t ^ (t>>4) ^ (t>>8) ^ (t>>16) ^ (t>>32)) & MAX_VAL
          n += 1                           
          s[n % 32] ^= (t&MAX_VAL)  #s[(n) % 32] ^= t, modified to reflect n change
          return s[n % 32]        #return s[(n) % 32], modified to reflect n change                      

      def del_bit(b, s):
          global n
          n -= 1
          add_bit(b,s), 
          n -= 1
          return s[n % 32]
          
      def init(s):
          global n
          n = 0
          h = 1
          for i in range(32):
              s[i]=0
          for i in range(4096):
              h=add_bit(h&1, s)
          n = 0    
      ###############################################################################

      def get_top_variable(variable_name="", default=None):
          '''
          Returns the value of a variable from the flow graph.
          '''
          ## Run Condition: GNURadio is starting the flowgraph, resulting output comes from here when working
          top = inspect.currentframe().f_back.f_back.f_locals
          try:
              # Check if top has the variable name we're looking for
              if top.__contains__(variable_name):
                  #print(f"[Block Debug 1] While starting, I found top variable \'{variable_name}\': type={type(top[variable_name])}, value={top[variable_name]}")
                  return top[variable_name]
          finally:
              del top

          ## Run Condition: Saving the flowgraph, necessary when default case isnt correct
          top = inspect.currentframe().f_back.f_back.f_back.f_back.f_back.f_locals
          try:
              # Make sure top has 'self'
              if top.__contains__("self") and \
                      (isinstance(top['self'], grc.gui.canvas.flowgraph.FlowGraph)) and \
                      (hasattr(top['self'], 'blocks')):

                  # Get a list of all blocks
                  block_names = [block.name for block in top['self'].blocks]

                  # Find the index to the variable we need
                  block_index = block_names.index(variable_name)
                  
                  # Return result
                  result = top['self'].blocks[block_index].params['value'].value
                  print(f"[Block Debug 2] While modifying the flowgraph, I found top variable \'{variable_name}\': type={type(result)}, value={result}")
                  return result

          finally:
              del top

          print("returining default vaule")
          return default
    comment: |-
      BBC Requires vectors
      for operation
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import glowworm.py
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: bytes
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bytes
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://127.0.0.1:5557"'
    timeout: '100'
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: '"tcp://127.0.0.1:5555"'
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_or_xx_0, '0', virtual_sink_1, '0']
- [blocks_stream_to_vector_0, '0', epy_block_2, '0']
- [blocks_stream_to_vector_0_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0_1, '0', epy_block_2_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_0, '0', blocks_tag_debug_0, '0']
- [blocks_throttle_0_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_throttle_0_0, '0', blocks_tag_debug_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_throttle_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_or_xx_0, '1']
- [blocks_vector_to_stream_1_0, '0', zeromq_push_sink_0, '0']
- [blocks_vector_to_stream_1_1, '0', blocks_or_xx_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_1_0, '0']
- [epy_block_0, msgOutput, blocks_message_debug_0, print]
- [epy_block_0, msgOutput, zeromq_push_msg_sink_0, in]
- [epy_block_2, '0', blocks_vector_to_stream_1, '0']
- [epy_block_2_0, '0', blocks_vector_to_stream_1_1, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
