options:
  parameters:
    author: James Morrison
    generate_options: qt_gui
    id: BBCCodecMaster
    output_language: python
    title: BBCCodec
  states: {}

blocks:
- name: CODEWORD_LENGTH
  id: variable
  parameters:
    comment: |-
      Subtract 3 since in Bytes
      131072 = 2**17
      512 = 2**9
    value: '131072'
  states: {}
- name: MESSAGE_LENGTH
  id: variable
  parameters:
    comment: |-
      Subtract 3 since in Bytes
      128 = 2**7
      8 = 2**3
    value: '128'
  states: {}
- name: message
  id: variable
  parameters:
    value: '"HELLO WORLD! Welcome to BBC in GNURadio. This is a jam-resistant codec, and we are sending messages, encoding them, and then try"'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: MESSAGE_LENGTH
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '32000'
    type: byte
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: '[ord(i) for i in message]'
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: MESSAGE_LENGTH
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      D E C O D E R
      """
      import sys
      import numpy as np
      from gnuradio import gr
      from gnuradio import grc
      import inspect
      DEFAULT_CHECKSUM = 0
      #TODO: REMOVE FIRST HANDLING TO MAKE VERSATILE
      global first
      first = True

      class blk(gr.sync_block):

          def __init__(self, msg_len=2**7, cod_len=2**17):
              msg_len = get_top_variable("MESSAGE_LENGTH", default=msg_len)
              cod_len = get_top_variable("CODEWORD_LENGTH", default=cod_len)
              
              gr.sync_block.__init__(self,
                  name='BBC Decoder',
                  in_sig=[(np.byte,  cod_len if isinstance(cod_len, int) else int(cod_len))],
                  out_sig=[(np.byte, msg_len if isinstance(msg_len, int) else int(msg_len))]
              )
              # Convert from Bytes to bits
              self.myDecoder = Decoder(msg_len*8, cod_len*8)
              sys.setrecursionlimit((msg_len+1)*8)

          # Use BBC to decode the incoming codeword vectors
          def work(self, input_items, output_items):
              result = self.myDecoder.decode(input_items[0][:][:])
              #TODO: add function to iteratively push results out
              try:
                  output_items[0][:][:] = bytearray(result[0].encode())
                  return len(output_items[0])
              except:
                  print("DEBUG decoder line 33: output typing failed.\n")
                  print("Type of decoder result: ", type(bytearray(result[0].encode())))
                  print("Type of stream: ", type(self.out_sig))

      ###############################################################################
      class Decoder:
          def __init__(self, msg_len, cod_len):
              self.message_list = []
              self.num_checksum = DEFAULT_CHECKSUM
              self.shift_register = self.init_shift_register()
              self.msg_len = msg_len
              self.cod_len = cod_len

          def init_shift_register(self):
              shift_register = [0 for i in range(32)]
              init(shift_register)
              return (shift_register)
          
          def decode(self, codeword):
              codeword = bytearray(codeword.tobytes()) #added for GRC implementation
              global first
              if(first):
                  first = False
                  self.message_list = []
                  message = bytearray(int(self.msg_len/8))
                  self._decode_BBC_recursive(message, codeword, 0) # make the first recursive call to decode
                  print("Message list- decoder--\n", str(self.message_list))
                  return self.message_list
          
          def _decode_BBC_recursive(self, message, codeword, index):
              # BASE CASE
              if index == (self.msg_len-1):
                  self.message_list.append(bytes(memoryview(message)[0:self.msg_len-1-self.num_checksum]).decode(encoding='ascii'))
                  
              # assuming the next message bit is a 0, check for a mark in the codeword
              else:
                  val = (add_bit(0, self.shift_register) % (self.cod_len))
                  bit = ((memoryview(codeword)[int((val-val%8)/8)])>>(val%8))& 0b1
                  if bit == 1: #TODO
                      try:
                          self._decode_BBC_recursive(message, codeword, index+1)
                      except:
                          print("Line 68. Recursion max length reached. current message: ", str(message), "Length at error = ", str(index)) #DEBUG
                  del_bit(0, self.shift_register)

                  # assuming the next message bit is a 1, check for a mark in the codeword
                  val = (add_bit(1, self.shift_register) % (self.cod_len))
                  bit =  (memoryview(codeword)[int((val-val%8)/8)]>>(val%8))& 0b1
                  if bit == 1: #(1<<val) == (codeword & (1<<val)):
                      memoryview(message)[int((index-index%8)/8)] |= (1<<index%8)
                      try:
                          self._decode_BBC_recursive(message, codeword, index+1)
                          memoryview(message)[int((index-index%8)/8)] &= (0xff ^ (1<<index%8)) #set one bit low
                      except:
                          print("Line 79. Recursion max length reached. current message: ", str(message), "Length at error = ", str(index)) #DEBUG
                  del_bit(1, self.shift_register)

      ###############################################################################
      MAX_VAL = 0xffffffffffffffff
      global n
      n = 0       
      def add_bit(b, s):
          global n
          t = (s[n % 32]^(0xffffffff if b else 0)) &MAX_VAL
          t = ((t|(t>>1)) ^ ((t<<1)&MAX_VAL))&MAX_VAL     # Have to enforce 64 bit condition on left shift     
          t = (t ^ (t>>4) ^ (t>>8) ^ (t>>16) ^ (t>>32)) & MAX_VAL
          n += 1                           
          s[n % 32] ^= (t&MAX_VAL)  #s[(n) % 32] ^= t, modified to reflect n change
          return s[n % 32]    #return s[(n) % 32], modified to reflect n change                      

      def del_bit(b, s):
          global n
          n -= 1
          add_bit(b,s), 
          n -= 1
          return s[n % 32]
          
      def init(s):
          global n
          n = 0
          h = 1
          for i in range(32):
              s[i]=0
          for i in range(4096):
              h=add_bit(h&1, s)
          n = 0    

      ###############################################################################
          
      def get_top_variable(variable_name="", default=None):
          '''
          Returns the value of a variable from the flow graph.
          '''

          # Let's go!
          try:
              ## Run Condition: GNURadio is starting the flowgraph
              top = inspect.currentframe().f_back.f_back.f_locals

              # Check if top has the variable name we're looking for
              if top.__contains__(variable_name):

                  # Let the user know we found the variable
                  print(f"[Block Debug] While starting, I found top variable \'{variable_name}\': type={type(top[variable_name])}, value={top[variable_name]}")

                  # Return the value of the variable name
                  return top[variable_name]

              ## Run Condition: Saving the flowgraph
              top = inspect.currentframe().f_back.f_back.f_back.f_back.f_back.f_locals

              # Make sure top has 'self'
              if top.__contains__("self") and \
                      (isinstance(top['self'], grc.gui.canvas.flowgraph.FlowGraph)) and \
                      (hasattr(top['self'], 'blocks')):

                  # Get a list of all blocks
                  block_names = [block.name for block in top['self'].blocks]

                  # Find the index to the variable we need
                  block_index = block_names.index(variable_name)

                  # Store the result
                  result = top['self'].blocks[block_index].params['value'].value

                  # Let the user know we found the variable
                  print(f"[Block Debug] While modifying the flowgraph, I found top variable \'{variable_name}\': type={type(result)}, value={result}")

                  # Return the value of the variable we found
                  return result

          # Something went wrong
          except Exception as e:
              print("[Block Debug]: Threw an exception", str(e))
          except:
              print("[Block Debug]: Threw an unknown exception.")

          # Return the default result
          return default
    cod_len: CODEWORD_LENGTH
    msg_len: MESSAGE_LENGTH
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      E N C O D E R
      """
      #import sys
      import numpy as np
      from gnuradio import gr
      from gnuradio import grc
      import inspect
      DEFAULT_CHECKSUM = 0




      class blk(gr.sync_block):
          
          def __init__(self, msg_len=2**7, cod_len=2**17):
              msg_len = get_top_variable("MESSAGE_LENGTH", default=msg_len)
              cod_len = get_top_variable("CODEWORD_LENGTH", default=cod_len)
              
              gr.sync_block.__init__(self,
                  name='BBC Encoder',
                  in_sig=[(np.byte,  msg_len if isinstance(msg_len, int) else int(msg_len))],    
                  out_sig=[(np.byte, cod_len if isinstance(cod_len, int) else int(cod_len))]
              )
              # Convert from Bytes to bits
              self.myEncoder = Encoder(msg_len*8, cod_len*8)
          
          
          # Use BBC to encode the incoming message vectors
          def work(self, input_items, output_items):
              result = self.myEncoder.encode(input_items[0][:][:])
              
              try:
                  output_items[0][:][:] = result
                  return len(output_items[0])
              except:
                  print("DEBUG encoder line 31: output typing failed.\n")
                  print("Type of encoder result: ", type(result))
                  print("Type of stream: ", type(self.out_sig))
          
      ###############################################################################
      class Encoder:
          def __init__(self, msg_len, cod_len):
              self.shift_register = self.init_shift_register()
              self.msg_len = msg_len
              self.cod_len = cod_len

          def init_shift_register(self):
              shift_register = [0 for i in range(32)]
              init(shift_register)
              return (shift_register)

          def parse_input(self, my_input):
              message = bytearray(my_input.tobytes())
              #TODO: add error exception for wrong sized input vector
              return message

          def encode(self, input):
              message = self.parse_input(input)
              codeword = bytearray(int(self.cod_len/8))
              
              for i in range(self.msg_len):
                  element = memoryview(message)[int((i-i%8)/8)]
                  bit = ((element) >> (i%8)) & 0b1
                  mark_loc = add_bit(bit, self.shift_register) % self.cod_len
                  memoryview(codeword)[int((mark_loc-mark_loc%8)/8)] |= (1<<(mark_loc%8))
                  # TODO: add + vs | change to python library
              return(codeword)
              
       ##############################################################################
      MAX_VAL = 0xffffffffffffffff
      global n
      n = 0       
      def add_bit(b, s):
          global n
          t = (s[n % 32]^(0xffffffff if b else 0)) &MAX_VAL
          t = ((t|(t>>1)) ^ ((t<<1)&MAX_VAL))&MAX_VAL     # Have to enforce 64 bit condition on left shift     
          t = (t ^ (t>>4) ^ (t>>8) ^ (t>>16) ^ (t>>32)) & MAX_VAL
          n += 1                           
          s[n % 32] ^= (t&MAX_VAL)  #s[(n) % 32] ^= t, modified to reflect n change
          return s[n % 32]        #return s[(n) % 32], modified to reflect n change                      

      def del_bit(b, s):
          global n
          n -= 1
          add_bit(b,s), 
          n -= 1
          return s[n % 32]
          
      def init(s):
          global n
          n = 0
          h = 1
          for i in range(32):
              s[i]=0
          for i in range(4096):
              h=add_bit(h&1, s)
          n = 0    
      ###############################################################################

      def get_top_variable(variable_name="", default=None):
          '''
          Returns the value of a variable from the flow graph.
          '''

          # Let's go!
          try:
              ## Run Condition: GNURadio is starting the flowgraph
              top = inspect.currentframe().f_back.f_back.f_locals

              # Check if top has the variable name we're looking for
              if top.__contains__(variable_name):

                  # Let the user know we found the variable
                  print(f"[Block Debug] While starting, I found top variable \'{variable_name}\': type={type(top[variable_name])}, value={top[variable_name]}")

                  # Return the value of the variable name
                  return top[variable_name]

              ## Run Condition: Saving the flowgraph
              top = inspect.currentframe().f_back.f_back.f_back.f_back.f_back.f_locals

              # Make sure top has 'self'
              if top.__contains__("self") and \
                      (isinstance(top['self'], grc.gui.canvas.flowgraph.FlowGraph)) and \
                      (hasattr(top['self'], 'blocks')):

                  # Get a list of all blocks
                  block_names = [block.name for block in top['self'].blocks]

                  # Find the index to the variable we need
                  block_index = block_names.index(variable_name)

                  # Store the result
                  result = top['self'].blocks[block_index].params['value'].value

                  # Let the user know we found the variable
                  print(f"[Block Debug] While modifying the flowgraph, I found top variable \'{variable_name}\': type={type(result)}, value={result}")

                  # Return the value of the variable we found
                  return result

          # Something went wrong
          except Exception as e:
              print("[Block Debug]: Threw an exception", e)
          except:
              print("[Block Debug]: Threw an unknown exception.")

          # Return the default result
          return default
    cod_len: CODEWORD_LENGTH
    comment: |-
      BBC Requires vectors
      for operation
    msg_len: MESSAGE_LENGTH
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import glowworm.py
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: bytes
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bytes
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: '"tcp://127.0.0.1:5557"'
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', epy_block_2, '0']
- [blocks_stream_to_vector_0_0, '0', epy_block_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_0, '0', blocks_tag_debug_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_throttle_0, '0']
- [blocks_vector_to_stream_1, '0', virtual_sink_1, '0']
- [blocks_vector_to_stream_1_0, '0', zeromq_push_sink_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_1_0, '0']
- [epy_block_2, '0', blocks_vector_to_stream_1, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
