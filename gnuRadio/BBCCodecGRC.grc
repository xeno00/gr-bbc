options:
  parameters:
    author: James Morrison
    generate_options: qt_gui
    id: BBCCodecMaster
    output_language: python
    title: BBCCodec
  states: {}

blocks:
- name: CODEWORD_LENGTH
  id: variable
  parameters:
    value: 2**20
  states: {}
- name: MESSAGE_LENGTH
  id: variable
  parameters:
    value: 2**10
  states: {}
- name: codeword
  id: variable
  parameters:
    value: '"HELLOWORLD"'
  states: {}
- name: inStreamFunc
  id: variable_function_probe
  parameters:
    block_id: inStreamProbe
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {state: disabled}
- name: inStreamQT
  id: variable_qtgui_label
  parameters:
    label: inStream
    type: int
    value: inStreamFunc
  states: {state: disabled}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {state: disabled}
- name: variable_function_probe_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_vx_0
    comment: blocks_probe_signal_vx_0
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {state: disabled}
- name: variable_function_probe_0_0_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_vx_0_0
    comment: blocks_probe_signal_vx_0
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {state: disabled}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: outStream
    type: raw
    value: variable_function_probe_0
  states: {state: disabled}
- name: variable_qtgui_label_0_0_0
  id: variable_qtgui_label
  parameters:
    label: Message
    type: raw
    value: variable_function_probe_0_0_0
  states: {state: disabled}
- name: variable_qtgui_label_0_0_0_0
  id: variable_qtgui_label
  parameters:
    label: Codeword
    type: raw
    value: variable_function_probe_0_0_0_0
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: testOutput.txt
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_probe_signal_vx_0
  id: blocks_probe_signal_vx
  parameters:
    type: byte
    vlen: MESSAGE_LENGTH
  states: {state: disabled}
- name: blocks_probe_signal_vx_0_0
  id: blocks_probe_signal_vx
  parameters:
    type: byte
    vlen: CODEWORD_LENGTH
  states: {state: disabled}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: 2**20
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '32000'
    type: byte
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[ord(i) for i in codeword]'
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: 2**20
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: 2**10
    type: byte
  states: {}
- name: bpsk_mod_0
  id: bpsk_mod
  parameters: {}
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      DEFAULT_CHECKSUM = 0
      global first
      first = True

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, msg_len=2**10, cod_len=2**20):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BBC Decoder',   # will show up in GRC
                  in_sig=[(np.byte, cod_len)],
                  out_sig=[(np.byte, msg_len)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.myDecoder = Decoder(msg_len, cod_len)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:][:] = self.myDecoder.decode(input_items[0][:][:])
              return len(output_items[0])

      #################################################################################################
      class Decoder:
          def __init__(self, msg_len, cod_len):
              self.message_list = []
              self.num_checksum = DEFAULT_CHECKSUM
              self.shift_register = self.init_shift_register()
              self.msg_len = msg_len
              self.cod_len = cod_len

          def init_shift_register(self):
              shift_register = [0 for i in range(32)]
              init(shift_register)
              return (shift_register)
          
          def decode(self, codeword):
              codeword = bytearray(codeword.tobytes()) #added for GRC implementation
              global first
              if(first):
                  #print(codeword)
                  first = False
                  self.message_list = []
                  message = bytearray(self.msg_len)
                  self._decode_BBC_recursive(message, codeword, 0) # make the first recursive call to decode
                  #return self.message_list
                  print(self.message_list)
          
          def _decode_BBC_recursive(self, message, codeword, index):
              if index == (self.msg_len-1):
                      self.message_list.append(bytes(memoryview(message)[0:self.msg_len-1-self.num_checksum]).decode(encoding='ascii'))
              else:
                  # assuming the next message bit is a 0, check for a mark in the codeword
                  val = (add_bit(0, self.shift_register) % (self.cod_len))
                  bit = ((memoryview(codeword)[int((val-val%8)/8)])>>(val%8))& 0b1
                  if bit == 1: #TODO
                      try:
                          self._decode_BBC_recursive(message, codeword, index+1)
                      except:
                          print("max depth on 0 path: ", index)
                  del_bit(0, self.shift_register)

                  # assuming the next message bit is a 1, check for a mark in the codeword
                  val = (add_bit(1, self.shift_register) % (self.cod_len))
                  bit =  (memoryview(codeword)[int((val-val%8)/8)]>>(val%8))& 0b1
                  if bit == 1: #(1<<val) == (codeword & (1<<val)):
                      memoryview(message)[int((index-index%8)/8)] += (1<<index%8)
                      try:
                          self._decode_BBC_recursive(message, codeword, index+1)
                      except:
                          print("current codeword: ", codeword)
                          print("max depth on 1 path: ", index) #DEBUG
                  del_bit(1, self.shift_register)

      #################################################################################################
      MAX_VAL = 0xffffffffffffffff
      global n
      n = 0       
      def add_bit(b, s):
          global n
          t = (s[n % 32]^(0xffffffff if b else 0)) &MAX_VAL
          t = ((t|(t>>1)) ^ ((t<<1)&MAX_VAL))&MAX_VAL     # Have to enforce 64 bit condition on left shift     
          t = (t ^ (t>>4) ^ (t>>8) ^ (t>>16) ^ (t>>32)) & MAX_VAL
          n += 1                           
          s[n % 32] ^= (t&MAX_VAL)  #s[(n) % 32] ^= t, modified to reflect n change
          return s[n % 32]    #return s[(n) % 32], modified to reflect n change                      

      def del_bit(b, s):
          global n
          n -= 1
          add_bit(b,s), 
          n -= 1
          return s[n % 32]
          
      def init(s):
          global n
          n = 0
          h = 1
          for i in range(32):
              s[i]=0
          for i in range(4096):
              h=add_bit(h&1, s)
          n = 0    
    cod_len: CODEWORD_LENGTH
    msg_len: MESSAGE_LENGTH
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,output_chunk_size=8,dbug=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Byte Passthrough Block',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              self.message_port_register_out(pmt.intern('msgs'))

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.dbug = dbug
              self.output_chunk_size = output_chunk_size

          def forecast(self, noutput_items, ninput_items_required):
              for i in range(len(ninput_items_required)):
                  ninput_items_required[i] = noutput_items

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              if self.dbug:
                  self.message_port_pub(pmt.intern('msgs'), pmt.intern('Received ' + str(len(out0)) + ' items'))
      #        for i in range(len(in0)):
      #            output_items[0][:] = in0[i:i+self.output_chunk_size]
      #            i+=self.output_chunk_size
              #self.consume(0,self.output_chunk_size)
              out0[:] = in0[:]
              self.consume(0,len(out0[:]))
              return (len(out0[:]))
    dbug: '1'
    output_chunk_size: len(codeword)
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      DEFAULT_CHECKSUM = 0

      class blk(gr.sync_block):

          def __init__(self, msg_len=2**10, cod_len=2**20):
              #GR Interpretable variables, names and ports
              gr.sync_block.__init__(self,
                  name='BBC Encoder',
                  in_sig=[(np.byte, msg_len)],
                  out_sig=[(np.byte, cod_len)]
              )
              #self.cod_len = cod_len
              self.myEncoder = Encoder(msg_len, cod_len)
          
          # Use BBC to encode the incoming vectors
          def work(self, input_items, output_items):
              output_items[0][:][:] = self.myEncoder.encode(input_items[0][:][:])
              return len(output_items[0])
          
      ###############################################################################
      class Encoder:
          def __init__(self, msg_len, cod_len):
              self.shift_register = self.init_shift_register()
              self.msg_len = msg_len
              self.cod_len = cod_len

          def init_shift_register(self):
              shift_register = [0 for i in range(32)]
              init(shift_register)
              return (shift_register)

          def parse_input(self, my_input):
              #print("parsing", my_input)
              #if(type(my_input)==type("string")):
              #    my_input = my_input.encode(encoding="ASCII")
              message = bytearray(my_input.tobytes())#bytearray(MSG_LEN)
              #print("message = ", message)
              #memoryview(message)[0:(len(input))] = input
              return message

          def encode(self, input):
              #print("parsing ", input)
              message = self.parse_input(input)
              #print("message ", message)
              codeword = bytearray(self.cod_len)
              for i in range(self.msg_len):
                  element = memoryview(message)[int((i-i%8)/8)]
                  bit = ((element) >> (i%8)) & 0b1
                  mark_loc = add_bit(bit, self.shift_register) % self.cod_len
                  memoryview(codeword)[int((mark_loc-mark_loc%8)/8)] |= (1<<(mark_loc%8))
                  # Was error for adding 10000000, so changed to | instead of +
              #print(codeword==0)
              return(codeword)
              
       ##############################################################################
      MAX_VAL = 0xffffffffffffffff
      global n
      n = 0       
      def add_bit(b, s):
          global n
          t = (s[n % 32]^(0xffffffff if b else 0)) &MAX_VAL
          t = ((t|(t>>1)) ^ ((t<<1)&MAX_VAL))&MAX_VAL     # Have to enforce 64 bit condition on left shift     
          t = (t ^ (t>>4) ^ (t>>8) ^ (t>>16) ^ (t>>32)) & MAX_VAL
          n += 1                           
          s[n % 32] ^= (t&MAX_VAL)  #s[(n) % 32] ^= t, modified to reflect n change
          return s[n % 32]    #return s[(n) % 32], modified to reflect n change                      

      def del_bit(b, s):
          global n
          n -= 1
          add_bit(b,s), 
          n -= 1
          return s[n % 32]
          
      def init(s):
          global n
          n = 0
          h = 1
          for i in range(32):
              s[i]=0
          for i in range(4096):
              h=add_bit(h&1, s)
          n = 0    
    cod_len: CODEWORD_LENGTH
    msg_len: MESSAGE_LENGTH
  states: {}
- name: inStreamProbe
  id: blocks_probe_signal_x
  parameters:
    type: byte
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bpsk
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: bytes
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bytes
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: '"tcp://127.0.0.1:5557"'
    timeout: '100'
    type: byte
  states: {state: disabled}

connections:
- [blocks_stream_to_vector_0, '0', blocks_probe_signal_vx_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_2, '0']
- [blocks_stream_to_vector_0_0, '0', epy_block_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_0, '0', blocks_tag_debug_0, '0']
- [blocks_throttle_0, '0', inStreamProbe, '0']
- [blocks_vector_source_x_0_0, '0', blocks_throttle_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_probe_signal_x_0, '0']
- [blocks_vector_to_stream_1, '0', bpsk_mod_0, '0']
- [blocks_vector_to_stream_1, '0', epy_block_0_0, '0']
- [blocks_vector_to_stream_1, '0', virtual_sink_1, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_file_sink_0, '0']
- [bpsk_mod_0, '0', virtual_sink_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_1_0, '0']
- [epy_block_0_0, '0', zeromq_push_sink_0, '0']
- [epy_block_0_0, msgs, blocks_message_debug_0, print]
- [epy_block_2, '0', blocks_probe_signal_vx_0_0, '0']
- [epy_block_2, '0', blocks_vector_to_stream_1, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
