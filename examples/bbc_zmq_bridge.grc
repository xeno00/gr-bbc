options:
  parameters:
    author: James Morrison
    description: Decode BBC codewords arriving over ZeroMQ and push the messages back out.
    generate_options: no_gui
    id: bbc_zmq_bridge
    output_language: python
    run_options: run
    title: BBC ZeroMQ Bridge
  states: {}

blocks:
- name: MESSAGE_LENGTH
  id: variable
  parameters:
    comment: Must match both scripts.
    value: '32'
  states: {}
- name: CODEWORD_LENGTH
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: CHECKSUM_BITS
  id: variable
  parameters:
    value: '32'
  states: {}
- name: codeword_address
  id: variable
  parameters:
    comment: zmq_tx_bbc.py binds here; this flow graph connects.
    value: '''tcp://127.0.0.1:5555'''
  states: {}
- name: message_address
  id: variable
  parameters:
    comment: This flow graph binds here; zmq_receive_bbc.py connects.
    value: '''tcp://127.0.0.1:5556'''
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    comment: One codeword per ZeroMQ message keeps the vectors aligned.
    address: codeword_address
    timeout: '100'
    type: byte
    vlen: CODEWORD_LENGTH
  states: {}
- name: bbc_bbc_decoder_0
  id: bbc_bbc_decoder
  parameters:
    message_length: MESSAGE_LENGTH
    codeword_length: CODEWORD_LENGTH
    checksum_length: CHECKSUM_BITS
    max_candidates: '256'
    max_steps: '5000000'
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    comment: Decoded messages back out to zmq_receive_bbc.py.
    address: message_address
    timeout: '100'
    type: byte
    vlen: MESSAGE_LENGTH
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Also prints locally.
  states: {}

connections:
- [zeromq_pull_source_0, '0', bbc_bbc_decoder_0, '0']
- [bbc_bbc_decoder_0, '0', zeromq_push_sink_0, '0']
- [bbc_bbc_decoder_0, decoded, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
