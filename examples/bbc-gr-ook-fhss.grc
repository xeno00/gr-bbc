options:
  parameters:
    author: James Morrison
    generate_options: qt_gui
    id: BBCCodecMaster
    output_language: python
    title: BBCCodec
  states: {}

blocks:
- name: CODEWORD_LENGTH
  id: variable
  parameters:
    comment: |-
      Must write as int
      Subtract 3 from exponent
      since in Bytes
      131072 = 2**17
      512 = 2**9
    value: '64'
  states: {}
- name: MESSAGE_LENGTH
  id: variable
  parameters:
    comment: |-
      Must write as int
      Subtract 3 from exponent
      since in Bytes
      128 = 2**7
      8 = 2**3
    value: '4'
  states: {}
- name: carrier_offset
  id: variable
  parameters:
    comment: Digital offset relative to the SDR center frequency
    value: '0.0'
  states: {}
- name: freqcmd1
  id: variable
  parameters:
    value: '"-1e6"'
  states: {}
- name: freqcmd1
  id: variable
  parameters:
    value: '"0"'
  states: {state: disabled}
- name: freqcmd2
  id: variable
  parameters:
    value: '"+2e6"'
  states: {}
- name: freqcmd2
  id: variable
  parameters:
    value: '"0"'
  states: {state: disabled}
- name: message1
  id: variable
  parameters:
    value: '"HELLO WORLD! Welcome to BBC in GNURadio. This is a jam-resistant codec, and we are sending messages, encoding them, and then try"'
  states: {}
- name: message2
  id: variable
  parameters:
    value: '"ZELLO ZORLD! Zelcome zo ZBC zn ZNURadio. Zhis zs z zam-zesistant zodec, znd ze zre zending zessages, zncoding zhem, znd zhen zry"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 128e3
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: int (500)
  states: {}
- name: OOKDemodulator_0
  id: bbc_ook_demodulator
  parameters:
    sample_rate: samp_rate
    symbol_rate: '500'
    threshold: '0.5'
  states: {}
- name: OOKModulator_0
  id: bbc_ook_modulator
  parameters:
    carrier_frequency: carrier_offset
    sample_rate: samp_rate
    symbol_rate: symbol_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: CODEWORD_LENGTH
  states: {}
- name: blocks_or_xx_0
  id: blocks_or_xx
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: MESSAGE_LENGTH
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: MESSAGE_LENGTH
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[ord(i) for i in freqcmd2]'
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[ord(i) for i in freqcmd1]'
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: MESSAGE_LENGTH
    type: byte
  states: {state: disabled}
- name: blocks_vector_to_stream_1_1
  id: blocks_vector_to_stream
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      D E C O D E R
      """
      #import sys    #sys.setrecursionlimit((msg_len+1)*8)    after gr.sync_block.__init__()
      import numpy as np
      from gnuradio import gr
      from gnuradio import grc
      from math import ceil
      import inspect
      import pmt
      import time

      DEFAULT_CHECKSUM = 0
      #TODO: REMOVE FIRST HANDLING TO MAKE VERSATILE
      global first
      first = True

      class blk(gr.interp_block):

          def __init__(self): #If there is an error, change default here:
              msg_len = get_top_variable("MESSAGE_LENGTH", default=2**2)#2**7)
              cod_len = get_top_variable("CODEWORD_LENGTH", default=64)#2**17)
              
              gr.sync_block.__init__(self,
                  name='BBC Decoder',
                  in_sig=[(np.byte,  cod_len if isinstance(cod_len, int) else int(cod_len))],
                  #out_sig=[(np.byte, msg_len if isinstance(msg_len, int) else int(msg_len))]
                  out_sig = [(np.byte, cod_len if isinstance(cod_len, int) else int(cod_len))]
              #out_sig=None
              )
              self.portOutName = 'frequencyCmd'
              self.message_port_register_out(pmt.intern(self.portOutName))
              self.set_relative_rate(1)
              self.prev_msg =[]
              # Convert from Bytes to bits
              self.myDecoder = Decoder(msg_len*8, cod_len*8, DEFAULT_CHECKSUM) # Bytes to bits
              #sys.setrecursionlimit((msg_len+1)*8)

          # Use BBC to decode the incoming codeword vectors
          def work(self, input_items, output_items):
              
              # Pull packet from the queue
              packet = input_items[0][:][0]
              
              # Check for a nonzero codeword
              #if sum(packet is not None):
                  
              #print("\nDecoder heard codeword ", packet)
              result = self.myDecoder.decode(packet)
              interp = len(result)
                  
              #Check for a decoded message
              if interp > 0:
                      
                  ## Definre the number of outputs
                  #self.set_relative_rate(interp)
                  # import pdb
                  # pdb.set_trace()
                  self.prev_msg = result
                  for msg in self.prev_msg:
                      msg = float(msg.decode())
                      #output_items[0][:] = msg
                      PMT_msg = pmt.cons(pmt.intern("freq"), pmt.from_double(msg))
                      self.message_port_pub(pmt.intern(self.portOutName), PMT_msg)
                      time.sleep(0.2)
                      #consume()
              else:
                  for msg in self.prev_msg:
                      msg = float(msg.decode())
                      #output_items[0][:] = msg
                      PMT_msg = pmt.cons(pmt.intern("freq"), pmt.from_double(msg))
                      self.message_port_pub(pmt.intern(self.portOutName), PMT_msg)
                      time.sleep(0.2)
                      # Assign outputs iteratively
                  # for j in range(interp):
                  #     try:
                  #         #output_items[0][j][:] = result[j]
                  #         #print("BBC decoder found and passed", result[j])
                  #         #P_freq_cmd = pmt.cons(pmt.string_to_symbol("freq"), pmt.from_double(freq)) # from learning fhss
                  #
                  #         PMT_msg = pmt.cons(pmt.intern("freq"),pmt.intern(result[j]))
                  #         self.message_port_pub(pmt.intern(self.portOutName), PMT_msg)
                  #     except:
                  #             # Decrement the expected output size
                  #             #interp -= 1
                  #             print("\nDebug: Fix integer max in byte output of decoder. Failed to output:", result[j])
                  #return len(output_items) #interp
              #output_items[0][:] = input_items[0]
              return len(output_items)

      ###############################################################################
      class Decoder:
          def __init__(self, MSG_LEN, COD_LEN, CHK_LEN = 0):
              self.message_list = []
              self.num_checksum = DEFAULT_CHECKSUM
              self.shift_register = self.init_shift_register()
              self.MSG_LEN = MSG_LEN
              self.COD_LEN = COD_LEN
              self.CHK_LEN = CHK_LEN #Is added to MSG_LEN, not subtracted from
              self.n = 0

          def init_shift_register(self):
              shift_register = [0 for i in range(32)]
              init(shift_register)
              return (shift_register)

          #DECODE ITERATIVELY
          #Note that   D[n]   is the same as    memoryview(message)[int((self.n - self.n%8)/8)]
          def decode(self, packet):
              # Initialize variables
              self.message_list = []
              message = bytearray(ceil((self.MSG_LEN + self.CHK_LEN)/8))      #Bits to Bytes
              #memoryview(message)[int((self.n - self.n%8)/8)] = 1         # TODO: debug initialization for D[n]
              
              while True:
                  # Check for mark corresponding to encoding D[n], beginning with a 0
                  prop_bit = (memoryview(message)[int((self.n - self.n%8)/8)]>>(self.n%8)) & 0b1      # Find the proposed bit from previous execution, aka D[n]
                  val = (add_bit(prop_bit, self.shift_register) % (self.COD_LEN))                  # Mark location from glowworm
                  bit = (memoryview(packet)[int((val-val%8)/8)]>>(val%8)) & 0b1                       # Logical AND to determine if present in packet/codeword

                  # If the mark is present... explore
                  if bit==1:
                      # message is complete, write to buffer
                      if self.n == (self.MSG_LEN + self.CHK_LEN - 1):
                          #print(message)
                          valid_msg = bytearray(memoryview(message)[0:self.MSG_LEN - 1 - self.num_checksum])
                          self.message_list.append(bytes(message))
                          bit = 0
                          #TODO: Flow control statement?
                          
                      # message is incomplete, continue assuming next bit is 0
                      elif self.n < (self.MSG_LEN + self.CHK_LEN - 1):
                          self.n += 1
                          memoryview(message)[int((self.n - self.n%8)/8)] &= (0xff ^ (1<<self.n%8))
                          continue
                      # In case something bad happens
                      else:
                          raise Exception("107: Message completion led to over-indexing")


                  # If the mark is not present... backtrace
                  # Settle on an earlier 0 to change it to a 1 and pursue that tree
                  if bit!=1:
                      # delete checksum bits
                      while self.n >= self.MSG_LEN: 
                          del_bit(0, self.shift_register)
                          self.n -= 1
                          
                      # delete 1's until a 0 is encountered
                      while self.n >=0 and (((memoryview(message)[int((self.n - self.n%8)/8)]>>(self.n%8)) & 0b1 )==1):
                          del_bit(1, self.shift_register)
                          memoryview(message)[int((self.n - self.n%8)/8)] &= (0xff ^ (1<<self.n%8))
                          self.n -= 1
                              
                      if self.n < 0: #Packet is fully decoded
                          #print("BBC Decoder line 116: Packet is fully decoded. ")
                          break #proceed with next packet

                      else: # Move over to the 1 branch of current search
                          del_bit(0, self.shift_register)
                          memoryview(message)[int((self.n - self.n%8)/8)] |= (1<<self.n%8)
              #for x in self.message_list:
              #    print("Non-iterative output: ",x)
              return self.message_list

      ###############################################################################
      MAX_VAL = 0xffffffffffffffff
      global n
      n = 0       
      def add_bit(b, s):
          global n
          t = (s[n % 32]^(0xffffffff if b else 0)) &MAX_VAL
          t = ((t|(t>>1)) ^ ((t<<1)&MAX_VAL))&MAX_VAL     # Have to enforce 64 bit condition on left shift     
          t = (t ^ (t>>4) ^ (t>>8) ^ (t>>16) ^ (t>>32)) & MAX_VAL
          n += 1                           
          s[n % 32] ^= (t&MAX_VAL)  #s[(n) % 32] ^= t, modified to reflect n change
          return s[n % 32]    #return s[(n) % 32], modified to reflect n change                      

      def del_bit(b, s):
          global n
          n -= 1
          add_bit(b,s), 
          n -= 1
          return s[n % 32]
          
      def init(s):
          global n
          n = 0
          h = 1
          for i in range(32):
              s[i]=0
          for i in range(4096):
              h=add_bit(h&1, s)
          n = 0    

      ###############################################################################
          
      def get_top_variable(variable_name="", default=None):
          '''
          Returns the value of a variable from the flow graph.
          '''
          ## Run Condition: GNURadio is starting the flowgraph, resulting output comes from here when working
          top = inspect.currentframe().f_back.f_back.f_locals
          try:
              # Check if top has the variable name we're looking for
              if top.__contains__(variable_name):
                  #print(f"[Block Debug 1] While starting, I found top variable \'{variable_name}\': type={type(top[variable_name])}, value={top[variable_name]}")
                  return top[variable_name]
          finally:
              del top
              
          ## Run Condition: Saving the flowgraph, necessary when default case isnt correct. Removed return to fix error
          top = inspect.currentframe().f_back.f_back.f_back.f_back.f_back.f_locals
          try:
              # Make sure top has 'self'
              if top.__contains__("self") and \
                      (isinstance(top['self'], grc.gui.canvas.flowgraph.FlowGraph)) and \
                      (hasattr(top['self'], 'blocks')):

                  # Get a list of all blocks
                  block_names = [block.name for block in top['self'].blocks]

                  # Find the index to the variable we need
                  block_index = block_names.index(variable_name)
                  
                  # Return result
                  result = top["self"].blocks[block_index].params['value'].value
                  print(result)
                  #print(f"[Block Debug 2] While modifying the flowgraph, I found top variable \'{variable_name}\': type={type(result)}, value={result}")
                  #return result
              
          finally:
              del top

          print("returining default vaule")
          return default
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      E N C O D E R
      """
      #import sys
      import numpy as np
      from gnuradio import gr
      from gnuradio import grc
      import inspect
      DEFAULT_CHECKSUM = 0




      class blk(gr.sync_block):
          
          def __init__(self):
              msg_len = get_top_variable("MESSAGE_LENGTH", default=2**7)
              cod_len = get_top_variable("CODEWORD_LENGTH", default=2**17)
              
              gr.sync_block.__init__(self,
                  name='BBC Encoder',
                  in_sig=[(np.byte,  msg_len if isinstance(msg_len, int) else int(msg_len))],    
                  out_sig=[(np.byte, cod_len if isinstance(cod_len, int) else int(cod_len))]
              )
              # Convert from Bytes to bits
              self.myEncoder = Encoder(msg_len*8, cod_len*8)
          
          
          # Use BBC to encode the incoming message vectors
          def work(self, input_items, output_items):
              result = self.myEncoder.encode(input_items[0][:])
              #print("encoded: ", result)
              
              try:
                  output_items[0][:] = result
                  return len(output_items[0])
              except:
                  print("DEBUG encoder line 31: output typing failed.\n")
                  print("Type of encoder result: ", type(result))
                  print("Type of stream: ", type(self.out_sig))
          
      ###############################################################################
      class Encoder:
          def __init__(self, msg_len, cod_len):
              self.shift_register = self.init_shift_register()
              self.msg_len = msg_len
              self.cod_len = cod_len

          def init_shift_register(self):
              shift_register = [0 for i in range(32)]
              init(shift_register)
              return (shift_register)

          def parse_input(self, my_input):
              message = bytearray(my_input.tobytes())
              #TODO: add error exception for wrong sized input vector
              return message

          def encode(self, input):
              message = self.parse_input(input)
              codeword = bytearray(int(self.cod_len/8))
              
              for i in range(self.msg_len):
                  element = memoryview(message)[int((i-i%8)/8)]
                  bit = ((element) >> (i%8)) & 0b1
                  mark_loc = add_bit(bit, self.shift_register) % self.cod_len
                  #print(mark_loc)
                  memoryview(codeword)[int((mark_loc-mark_loc%8)/8)] |= (1<<(mark_loc%8))
                  # TODO: add + vs | change to python library
              return(codeword)
              
       ##############################################################################
      MAX_VAL = 0xffffffffffffffff
      global n
      n = 0       
      def add_bit(b, s):
          global n
          t = (s[n % 32]^(0xffffffff if b else 0)) &MAX_VAL
          t = ((t|(t>>1)) ^ ((t<<1)&MAX_VAL))&MAX_VAL     # Have to enforce 64 bit condition on left shift     
          t = (t ^ (t>>4) ^ (t>>8) ^ (t>>16) ^ (t>>32)) & MAX_VAL
          n += 1                           
          s[n % 32] ^= (t&MAX_VAL)  #s[(n) % 32] ^= t, modified to reflect n change
          return s[n % 32]        #return s[(n) % 32], modified to reflect n change                      

      def del_bit(b, s):
          global n
          n -= 1
          add_bit(b,s), 
          n -= 1
          return s[n % 32]
          
      def init(s):
          global n
          n = 0
          h = 1
          for i in range(32):
              s[i]=0
          for i in range(4096):
              h=add_bit(h&1, s)
          n = 0    
      ###############################################################################

      def get_top_variable(variable_name="", default=None):
          '''
          Returns the value of a variable from the flow graph.
          '''
          ## Run Condition: GNURadio is starting the flowgraph, resulting output comes from here when working
          top = inspect.currentframe().f_back.f_back.f_locals
          try:
              # Check if top has the variable name we're looking for
              if top.__contains__(variable_name):
                  #print(f"[Block Debug 1] While starting, I found top variable \'{variable_name}\': type={type(top[variable_name])}, value={top[variable_name]}")
                  return top[variable_name]
          finally:
              del top

          ## Run Condition: Saving the flowgraph, necessary when default case isnt correct
          top = inspect.currentframe().f_back.f_back.f_back.f_back.f_back.f_locals
          try:
              # Make sure top has 'self'
              if top.__contains__("self") and \
                      (isinstance(top['self'], grc.gui.canvas.flowgraph.FlowGraph)) and \
                      (hasattr(top['self'], 'blocks')):

                  # Get a list of all blocks
                  block_names = [block.name for block in top['self'].blocks]

                  # Find the index to the variable we need
                  block_index = block_names.index(variable_name)
                  
                  # Return result
                  result = top['self'].blocks[block_index].params['value'].value
                  print(f"[Block Debug 2] While modifying the flowgraph, I found top variable \'{variable_name}\': type={type(result)}, value={result}")
                  return result

          finally:
              del top

          print("returining default vaule")
          return default
    comment: |-
      BBC Requires vectors
      for operation
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |
      """
      E N C O D E R
      """
      #import sys
      import numpy as np
      from gnuradio import gr
      from gnuradio import grc
      import inspect
      DEFAULT_CHECKSUM = 0




      class blk(gr.sync_block):
          
          def __init__(self):
              msg_len = get_top_variable("MESSAGE_LENGTH", default=2**7)
              cod_len = get_top_variable("CODEWORD_LENGTH", default=2**17)
              
              gr.sync_block.__init__(self,
                  name='BBC Encoder',
                  in_sig=[(np.byte,  msg_len if isinstance(msg_len, int) else int(msg_len))],    
                  out_sig=[(np.byte, cod_len if isinstance(cod_len, int) else int(cod_len))]
              )
              # Convert from Bytes to bits
              self.myEncoder = Encoder(msg_len*8, cod_len*8)
          
          
          # Use BBC to encode the incoming message vectors
          def work(self, input_items, output_items):
              result = self.myEncoder.encode(input_items[0][:][:])
              
              try:
                  output_items[0][:][:] = result
                  return len(output_items[0])
              except:
                  print("DEBUG encoder line 31: output typing failed.\n")
                  print("Type of encoder result: ", type(result))
                  print("Type of stream: ", type(self.out_sig))
          
      ###############################################################################
      class Encoder:
          def __init__(self, msg_len, cod_len):
              self.shift_register = self.init_shift_register()
              self.msg_len = msg_len
              self.cod_len = cod_len

          def init_shift_register(self):
              shift_register = [0 for i in range(32)]
              init(shift_register)
              return (shift_register)

          def parse_input(self, my_input):
              message = bytearray(my_input.tobytes())
              #TODO: add error exception for wrong sized input vector
              return message

          def encode(self, input):
              message = self.parse_input(input)
              codeword = bytearray(int(self.cod_len/8))
              
              for i in range(self.msg_len):
                  element = memoryview(message)[int((i-i%8)/8)]
                  bit = ((element) >> (i%8)) & 0b1
                  mark_loc = add_bit(bit, self.shift_register) % self.cod_len
                  memoryview(codeword)[int((mark_loc-mark_loc%8)/8)] |= (1<<(mark_loc%8))
                  # TODO: add + vs | change to python library
              return(codeword)
              
       ##############################################################################
      MAX_VAL = 0xffffffffffffffff
      global n
      n = 0       
      def add_bit(b, s):
          global n
          t = (s[n % 32]^(0xffffffff if b else 0)) &MAX_VAL
          t = ((t|(t>>1)) ^ ((t<<1)&MAX_VAL))&MAX_VAL     # Have to enforce 64 bit condition on left shift     
          t = (t ^ (t>>4) ^ (t>>8) ^ (t>>16) ^ (t>>32)) & MAX_VAL
          n += 1                           
          s[n % 32] ^= (t&MAX_VAL)  #s[(n) % 32] ^= t, modified to reflect n change
          return s[n % 32]        #return s[(n) % 32], modified to reflect n change                      

      def del_bit(b, s):
          global n
          n -= 1
          add_bit(b,s), 
          n -= 1
          return s[n % 32]
          
      def init(s):
          global n
          n = 0
          h = 1
          for i in range(32):
              s[i]=0
          for i in range(4096):
              h=add_bit(h&1, s)
          n = 0    
      ###############################################################################

      def get_top_variable(variable_name="", default=None):
          '''
          Returns the value of a variable from the flow graph.
          '''
          ## Run Condition: GNURadio is starting the flowgraph, resulting output comes from here when working
          top = inspect.currentframe().f_back.f_back.f_locals
          try:
              # Check if top has the variable name we're looking for
              if top.__contains__(variable_name):
                  #print(f"[Block Debug 1] While starting, I found top variable \'{variable_name}\': type={type(top[variable_name])}, value={top[variable_name]}")
                  return top[variable_name]
          finally:
              del top

          ## Run Condition: Saving the flowgraph, necessary when default case isnt correct
          top = inspect.currentframe().f_back.f_back.f_back.f_back.f_back.f_locals
          try:
              # Make sure top has 'self'
              if top.__contains__("self") and \
                      (isinstance(top['self'], grc.gui.canvas.flowgraph.FlowGraph)) and \
                      (hasattr(top['self'], 'blocks')):

                  # Get a list of all blocks
                  block_names = [block.name for block in top['self'].blocks]

                  # Find the index to the variable we need
                  block_index = block_names.index(variable_name)
                  
                  # Return result
                  result = top['self'].blocks[block_index].params['value'].value
                  print(f"[Block Debug 2] While modifying the flowgraph, I found top variable \'{variable_name}\': type={type(result)}, value={result}")
                  return result

          finally:
              del top

          print("returining default vaule")
          return default
    comment: |-
      BBC Requires vectors
      for operation
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '100'
    type: ccf
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ook_tx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ook_tx
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    timeout: '100'
    type: byte
  states: {state: disabled}

connections:
- [OOKDemodulator_0, '0', blocks_stream_to_vector_0_0, '0']
- [OOKModulator_0, '0', virtual_sink_0, '0']
- [analog_sig_source_x_0, '0', rational_resampler_xxx_0, '0']
- [blocks_or_xx_0, '0', OOKModulator_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_2, '0']
- [blocks_stream_to_vector_0_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0_1, '0', epy_block_2_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_0_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_vector_source_x_0_0, '0', blocks_throttle_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_or_xx_0, '1']
- [blocks_vector_to_stream_1_0, '0', blocks_null_sink_0, '0']
- [blocks_vector_to_stream_1_0, '0', zeromq_push_sink_0, '0']
- [blocks_vector_to_stream_1_1, '0', blocks_or_xx_0, '0']
- [epy_block_0, '0', blocks_null_sink_1, '0']
- [epy_block_0, frequencyCmd, blocks_message_debug_0, print]
- [epy_block_0, frequencyCmd, freq_xlating_fir_filter_xxx_1, freq]
- [epy_block_2, '0', blocks_vector_to_stream_1, '0']
- [epy_block_2_0, '0', blocks_vector_to_stream_1_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', qtgui_waterfall_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [virtual_source_0, '0', OOKDemodulator_0, '0']

metadata:
  file_format: 1
