options:
  parameters:
    author: James Morrison
    description: A jam-resistant BBC control channel that commands a frequency hop.
    generate_options: qt_gui
    id: bbc_fhss_control
    output_language: python
    title: BBC Frequency Hop Control
  states: {}

blocks:
- name: MESSAGE_LENGTH
  id: variable
  parameters:
    value: '8'
  states: {}
- name: CODEWORD_LENGTH
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: CHECKSUM_BITS
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 128e3
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    comment: Control channel, as a baseband offset.
    value: 20e3
  states: {}
- name: tone_freq
  id: variable
  parameters:
    comment: The payload signal that gets hopped.
    value: 5e3
  states: {}
- name: jam_amplitude
  id: variable
  parameters:
    comment: Jammer power relative to the control channel.
    value: '1.0'
  states: {}
- name: jam_bytes
  id: variable
  parameters:
    value: '[(i * 167 + 13) % 256 for i in range(4096)]'
  states: {}
- name: commands
  id: variable
  parameters:
    comment: Two hop commands, sent in turn.
    value: list(b'+20000'.ljust(MESSAGE_LENGTH, b'\x00')) + list(b'-20000'.ljust(MESSAGE_LENGTH, b'\x00'))
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: commands
    vlen: MESSAGE_LENGTH
  states: {}
- name: bbc_bbc_encoder_0
  id: bbc_bbc_encoder
  parameters:
    message_length: MESSAGE_LENGTH
    codeword_length: CODEWORD_LENGTH
    checksum_length: CHECKSUM_BITS
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: bbc_OOKModulator_0
  id: bbc_OOKModulator
  parameters:
    carrier_freq: carrier_freq
    samp_rate: samp_rate
    symbol_rate: symbol_rate
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    comment: Jammer payload
    repeat: 'True'
    type: byte
    vector: jam_bytes
  states: {}
- name: bbc_OOKModulator_1
  id: bbc_OOKModulator
  parameters:
    comment: Jammer on the control channel
    carrier_freq: carrier_freq
    samp_rate: samp_rate
    symbol_rate: symbol_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: jam_amplitude
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Marks are added, never removed.
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Keeps the waterfall running in real time.
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: bbc_OOKDemodulator_0
  id: bbc_OOKDemodulator
  parameters:
    bandwidth: None
    carrier_freq: carrier_freq
    samp_rate: samp_rate
    symbol_rate: symbol_rate
    threshold: '0.25'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: bbc_bbc_decoder_0
  id: bbc_bbc_decoder
  parameters:
    message_length: MESSAGE_LENGTH
    codeword_length: CODEWORD_LENGTH
    checksum_length: CHECKSUM_BITS
    max_candidates: '256'
    max_steps: '5000000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: MESSAGE_LENGTH
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    comment: Decoded message -> hop command
    _source_code: |
      """
      Turn a decoded BBC message into a frequency command.

      The control channel carries an ASCII offset in Hz, e.g. b"+20000". Each
      message that survives the jammer is republished as a `freq` PMT, which
      Frequency Xlating FIR Filter accepts on its `freq` port.
      """
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name="BBC Frequency Command",
                                      in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern("decoded"))
              self.message_port_register_out(pmt.intern("freq"))
              self.set_msg_handler(pmt.intern("decoded"), self.handle)

          def handle(self, msg):
              payload = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              text = payload.rstrip(b"\x00").decode("ascii", "ignore").strip()
              try:
                  offset = float(text)
              except ValueError:
                  return
              self.message_port_pub(
                  pmt.intern("freq"),
                  pmt.cons(pmt.intern("freq"), pmt.from_double(offset)))
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    comment: The signal being hopped.
    amp: '1'
    freq: tone_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    comment: Hops when the control channel says so.
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Hopping signal"'
    type: complex
  states: {}

connections:
- [blocks_vector_source_x_0, '0', bbc_bbc_encoder_0, '0']
- [bbc_bbc_encoder_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_to_stream_0, '0', bbc_OOKModulator_0, '0']
- [bbc_OOKModulator_0, '0', blocks_add_xx_0, '0']
- [blocks_vector_source_x_1, '0', bbc_OOKModulator_1, '0']
- [bbc_OOKModulator_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', bbc_OOKDemodulator_0, '0']
- [bbc_OOKDemodulator_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', bbc_bbc_decoder_0, '0']
- [bbc_bbc_decoder_0, '0', blocks_null_sink_0, '0']
- [bbc_bbc_decoder_0, decoded, blocks_message_debug_0, print]
- [bbc_bbc_decoder_0, decoded, epy_block_0, decoded]
- [epy_block_0, freq, freq_xlating_fir_filter_xxx_0, freq]
- [analog_sig_source_x_0, '0', blocks_throttle2_0_0, '0']
- [blocks_throttle2_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
