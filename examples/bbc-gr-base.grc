options:
  parameters:
    author: James Morrison
    generate_options: no_gui
    id: BBCCodecMaster
    output_language: python
    title: BBCCodec
  states: {}

blocks:
- name: CODEWORD_LENGTH
  id: variable
  parameters:
    comment: |-
      Must write as int
      Subtract 3 from exponent
      since in Bytes
      131072 = 2**17
      512 = 2**9
    value: '1024'
  states: {}
- name: MESSAGE_LENGTH
  id: variable
  parameters:
    comment: |-
      Must write as int
      Subtract 3 from exponent
      since in Bytes
      128 = 2**7
      8 = 2**3
    value: '128'
  states: {}
- name: message1
  id: variable
  parameters:
    value: '"HELLO WORLD! Welcome to BBC in GNURadio. This is a jam-resistant codec, and we are sending messages, encoding them, and then try"'
  states: {}
- name: message2
  id: variable
  parameters:
    value: '"ZO"'
  states: {state: disabled}
- name: message2
  id: variable
  parameters:
    value: '"ZELLO ZORLD! Zelcome zo ZBC zn ZNURadio. Zhis zs z zam-zesistant zodec, znd ze zre zending zessages, zncoding zhem, znd zhen zry"'
  states: {}
- name: bbc_bbc_decoder_0
  id: bbc_bbc_decoder
  parameters:
    codeword_length: CODEWORD_LENGTH
    max_candidates: '64'
    max_search_nodes: '1000000'
    message_length: MESSAGE_LENGTH
  states: {}
- name: bbc_bbc_encoder_0
  id: bbc_bbc_encoder
  parameters:
    codeword_length: CODEWORD_LENGTH
    message_length: MESSAGE_LENGTH
  states: {}
- name: bbc_bbc_encoder_0_0
  id: bbc_bbc_encoder
  parameters:
    codeword_length: CODEWORD_LENGTH
    message_length: MESSAGE_LENGTH
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: bbc_gr_base_output.txt
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(MESSAGE_LENGTH*2)
    type: byte
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: int(MESSAGE_LENGTH*2)
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_or_xx_0
  id: blocks_or_xx
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: MESSAGE_LENGTH
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: MESSAGE_LENGTH
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: '32000'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: '00011010'
    repeat: 'True'
    type: byte
    vector: '[27]'
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: '[ord(i) for i in message2]'
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[ord(i) for i in message1]'
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: MESSAGE_LENGTH
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_1
  id: blocks_vector_to_stream
  parameters:
    num_items: CODEWORD_LENGTH
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    comment: |-
      Need to put this script
       in the site-packages folder
    imports: import glowworm
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: bytes
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bytes
  states: {}
- name: zeromq_push_sink_0_0
  id: zeromq_push_sink
  parameters:
    address: '"tcp://127.0.0.1:5554"'
    timeout: '100'
    type: byte
  states: {state: disabled}

connections:
- [bbc_bbc_decoder_0, '0', blocks_vector_to_stream_1_0, '0']
- [bbc_bbc_encoder_0, '0', blocks_vector_to_stream_1_1, '0']
- [bbc_bbc_encoder_0_0, '0', blocks_vector_to_stream_1, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_head_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0_0, '0']
- [blocks_or_xx_0, '0', virtual_sink_1, '0']
- [blocks_stream_to_vector_0, '0', bbc_bbc_encoder_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', bbc_bbc_decoder_0, '0']
- [blocks_stream_to_vector_0_1, '0', bbc_bbc_encoder_0, '0']
- [blocks_throttle_0_0, '0', blocks_null_sink_1, '0']
- [blocks_vector_source_x_0, '0', blocks_or_xx_0, '1']
- [blocks_vector_source_x_0_0, '0', blocks_head_0_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_head_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_or_xx_0, '1']
- [blocks_vector_to_stream_1_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_null_sink_0, '0']
- [blocks_vector_to_stream_1_1, '0', blocks_or_xx_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
